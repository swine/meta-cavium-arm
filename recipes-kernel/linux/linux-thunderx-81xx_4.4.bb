inherit kernel

LICENSE = "GPLv2"
LIC_FILES_CHKSUM = "file://COPYING;md5=d7810fab7487fb0aad327b76f1be7cd7"
LINUX_VERSION ?= "4.4.3"
PROVIDES += "virtual/kernel"
COMPATIBLE_MACHINE = "cavium-thunderx-81xx"
ARCH = "arm64"
SRC_URI[md5sum] = "ef1e12f54b359f7e4254b7341ee0c4de"
SRCREV = "2134d97aa3a7ce38bb51f933f2e20cafde371085"

SRC_URI = "git://git.yoctoproject.org/linux-yocto-4.4;branch=standard/base"
#;tag=v4.4.3"
#SRC_URI = "http://git.yoctoproject.org/cgit/cgit.cgi/linux-yocto-dev/snapshot/linux-yocto-dev-4.4.3.zip"
SRC_URI += "file://defconfig"

SRC_URI += "file://0001-UBUNTU-SAUCE-no-up-version-Implement-version_signatu.patch"
SRC_URI += "file://0002-UBUNTU-SAUCE-no-up-hostap-Change-initial-operation-m.patch"
SRC_URI += "file://0003-UBUNTU-SAUCE-no-up-nbd-Change-default-partitions-per.patch"
SRC_URI += "file://0004-UBUNTU-SAUCE-no-up-cdrom-default-to-not-locking-the-.patch"
SRC_URI += "file://0005-UBUNTU-SAUCE-no-up-fix-build-error-with-CONFIG_BLK_D.patch"
SRC_URI += "file://0006-UBUNTU-SAUCE-no-up-Added-quirk-to-recognize-GE0301-3.patch"
SRC_URI += "file://0007-UBUNTU-SAUCE-no-up-add-support-for-installed-header-.patch"
SRC_URI += "file://0008-UBUNTU-SAUCE-no-up-x86-reboot-Make-Dell-Latitude-E65.patch"
SRC_URI += "file://0009-UBUNTU-SAUCE-no-up-x86-reboot-Make-Dell-Optiplex-790.patch"
SRC_URI += "file://0010-UBUNTU-SAUCE-no-up-x86-reboot-Make-Dell-Optiplex-990.patch"
SRC_URI += "file://0011-UBUNTU-SAUCE-no-up-x86-reboot-Make-Dell-Latitude-E62.patch"
SRC_URI += "file://0012-UBUNTU-SAUCE-no-up-Input-synaptics-add-second-varian.patch"
SRC_URI += "file://0013-UBUNTU-SAUCE-no-up-Input-synapticss-Set-buttonpad-pr.patch"
SRC_URI += "file://0014-UBUNTU-SAUCE-no-up-elide-some-ioctl-warnings-which-a.patch"
SRC_URI += "file://0015-UBUNTU-SAUCE-no-up-tools-hv-add-basic-manual-pages.patch"
SRC_URI += "file://0016-UBUNTU-SAUCE-no-up-Allow-filtering-of-cpufreq-driver.patch"
SRC_URI += "file://0017-UBUNTU-SAUCE-no-up-kconfig-in-debug-mode-some-0-leng.patch"
SRC_URI += "file://0018-UBUNTU-SAUCE-no-up-firmware-Update-bnx2x-to-current-.patch"
SRC_URI += "file://0019-UBUNTU-SAUCE-no-up-Remove-redundant-cis-firmware.patch"
SRC_URI += "file://0020-UBUNTU-SAUCE-no-up-Remove-redundant-ttusb-budget-fir.patch"
SRC_URI += "file://0021-UBUNTU-SAUCE-no-up-Remove-redundant-ositech-Xilinx7O.patch"
SRC_URI += "file://0022-UBUNTU-SAUCE-no-up-Remove-redundant-yamaha-ds1-firmw.patch"
SRC_URI += "file://0023-UBUNTU-SAUCE-no-up-Remove-redundant-keyspan_pda-firm.patch"
SRC_URI += "file://0024-UBUNTU-SAUCE-no-up-firmware-Remove-ess-files-duplica.patch"
SRC_URI += "file://0025-UBUNTU-SAUCE-no-up-firmware-Remove-kaweth-files-dupl.patch"
SRC_URI += "file://0026-UBUNTU-SAUCE-no-up-firmware-Remove-edgeport-files-du.patch"
SRC_URI += "file://0027-UBUNTU-SAUCE-no-up-firmware-Remove-ti_usb_3410_5052-.patch"
SRC_URI += "file://0028-UBUNTU-SAUCE-no-up-firmware-Remove-adaptec-files-dup.patch"
SRC_URI += "file://0029-UBUNTU-SAUCE-no-up-firmware-Remove-advansys-files-du.patch"
SRC_URI += "file://0030-UBUNTU-SAUCE-no-up-firmware-Remove-ambassador-files-.patch"
SRC_URI += "file://0031-UBUNTU-SAUCE-no-up-firmware-Remove-av7110-files-dupl.patch"
SRC_URI += "file://0032-UBUNTU-SAUCE-no-up-firmware-Remove-cpia2-files-dupli.patch"
SRC_URI += "file://0033-UBUNTU-SAUCE-no-up-firmware-Remove-obsolete-Myricom-.patch"
SRC_URI += "file://0034-UBUNTU-SAUCE-no-up-firmware-Upgrade-bnx2-to-current-.patch"
SRC_URI += "file://0035-UBUNTU-SAUCE-no-up-rds_ib_send-prevent-local-pings-t.patch"
SRC_URI += "file://0036-UBUNTU-SAUCE-no-up-vxge-Declare-MODULE_FIRMWARE-usag.patch"
SRC_URI += "file://0037-UBUNTU-SAUCE-no-up-fix-highbank-include-path.patch"
SRC_URI += "file://0038-UBUNTU-SAUCE-no-up-Remove-yam-files-duplicated-in-li.patch"
SRC_URI += "file://0039-UBUNTU-SAUCE-no-up-Remove-tehuti-files-duplicated-in.patch"
SRC_URI += "file://0040-UBUNTU-SAUCE-no-up-Remove-matrox-files-duplicated-in.patch"
SRC_URI += "file://0041-UBUNTU-SAUCE-no-up-Remove-cxgb3-files-duplicated-in-.patch"
SRC_URI += "file://0042-UBUNTU-SAUCE-no-up-Remove-r128-files-duplicated-in-l.patch"
SRC_URI += "file://0043-UBUNTU-SAUCE-no-up-Remove-acenic-files-duplicated-in.patch"
SRC_URI += "file://0044-UBUNTU-SAUCE-no-up-Remove-keyspan-files-duplicated-i.patch"
SRC_URI += "file://0045-UBUNTU-SAUCE-no-up-Remove-sun-files-duplicated-in-li.patch"
SRC_URI += "file://0046-UBUNTU-SAUCE-no-up-Remove-radeon-files-duplicated-in.patch"
#SRC_URI += "file://0047-UBUNTU-SAUCE-no-up-Update-bnx2x-firmware-to-7.8.2.0.patch"
#SRC_URI += "file://0048-UBUNTU-SAUCE-no-up-Remove-dsp56k-files-used-only-by-.patch"
SRC_URI += "file://0049-UBUNTU-SAUCE-no-up-Remove-vicam-files-duplicated-in-.patch"
SRC_URI += "file://0050-UBUNTU-SAUCE-no-up-Revert-VFS-don-t-do-protected-sym.patch"
SRC_URI += "file://0051-UBUNTU-SAUCE-no-up-hv-Supply-vendor-ID-and-package-A.patch"
SRC_URI += "file://0052-UBUNTU-SAUCE-no-up-Input-Cypress-PS-2-Trackpad-simul.patch"
#SRC_URI += "file://0053-UBUNTU-SAUCE-no-up-Convert-bnx2x-firmware-files-to-i.patch"
SRC_URI += "file://0054-UBUNTU-SAUCE-no-up-PCI-fix-system-hang-issue-of-Marv.patch"
SRC_URI += "file://0055-UBUNTU-SAUCE-no-up-x86-reboot-Make-Dell-Optiplex-390.patch"
SRC_URI += "file://0056-UBUNTU-SAUCE-no-up-trace-add-trace-events-for-open-e.patch"
#SRC_URI += "file://0057-UBUNTU-SAUCE-no-up-Update-bnx2x-firmware-to-7.8.17.0.patch"
SRC_URI += "file://0058-UBUNTU-SAUCE-no-up-intel_ips-blacklist-ASUSTek-G60JX.patch"
SRC_URI += "file://0059-UBUNTU-SAUCE-no-up-ACPI-Disable-Windows-8-compatibil.patch"
SRC_URI += "file://0060-UBUNTU-SAUCE-isapnp_init-make-isa-PNP-scans-occur-as.patch"
SRC_URI += "file://0061-UBUNTU-SAUCE-uvcvideo-quirk-PROBE_DEF-for-Alienware-.patch"
SRC_URI += "file://0062-UBUNTU-SAUCE-disable-stack-protector-for-ARM-compres.patch"
SRC_URI += "file://0063-UBUNTU-SAUCE-tg3-Add-support-for-new-57786-device-id.patch"
SRC_URI += "file://0064-UBUNTU-SAUCE-suspicious-unlocked-status-reading-and-.patch"
SRC_URI += "file://0065-UBUNTU-SAUCE-ARM-OMAP-hwmod-Add-SYSC-offsets-for-AES.patch"
SRC_URI += "file://0066-UBUNTU-SAUCE-ARM-OMAP4-hwmod-Add-hwmod-data-for-AES-.patch"
SRC_URI += "file://0067-UBUNTU-SAUCE-OMAP-AM33xx-hwmod-Correct-AES-module-SY.patch"
SRC_URI += "file://0068-UBUNTU-SAUCE-phylib-Minimum-hack-to-get-the-generic-.patch"
SRC_URI += "file://0069-UBUNTU-SAUCE-PPC-PCI-Fix-pcibios_io_space_offset-so-.patch"
SRC_URI += "file://0070-UBUNTU-SAUCE-Revert-phy-vitesse-make-vsc824x_add_ske.patch"
SRC_URI += "file://0071-UBUNTU-SAUCE-Fixup-freescale-usb-phy-driver-to-work-.patch"
SRC_URI += "file://0072-UBUNTU-SAUCE-Provide-booke-stub-for-kvmppc_is_bigend.patch"
SRC_URI += "file://0073-UBUNTU-SAUCE-allow-IRQs-to-be-irq-threaded-by-defaul.patch"
SRC_URI += "file://0074-UBUNTU-SAUCE-vt-maintain-bootloader-screen-mode-and-.patch"
SRC_URI += "file://0075-UBUNTU-SAUCE-no-up-mei_me-Add-module-parameter-to-di.patch"
SRC_URI += "file://0076-UBUNTU-SAUCE-kthread-Do-not-leave-kthread_create-imm.patch"
SRC_URI += "file://0077-UBUNTU-SAUCE-kvm-BIOS-disabled-kvm-support-should-be.patch"
SRC_URI += "file://0078-UBUNTU-SAUCE-nouveau-missing-outputs-should-be-warni.patch"
SRC_URI += "file://0079-UBUNTU-SAUCE-bcache-prevent-crash-on-changing-writeb.patch"
SRC_URI += "file://0080-UBUNTU-SAUCE-drivers-rtc-interface.c-ignore-exprired.patch"
SRC_URI += "file://0081-UBUNTU-SAUCE-rtsx_usb_ms-Use-msleep_interruptible-in.patch"
#SRC_URI += "file://0082-UBUNTU-SAUCE-no-up-Update-bnx2x-firmware-to-7.10.51..patch"
SRC_URI += "file://0083-UBUNTU-SAUCE-Fix-FTBS-in-proc_version_signature.patch"
SRC_URI += "file://0084-UBUNTU-SAUCE-fan-tunnel-multiple-mapping-mode-v3.patch"
SRC_URI += "file://0085-UBUNTU-SAUCE-overlay-add-backwards-compatible-overla.patch"
SRC_URI += "file://0086-UBUNTU-SAUCE-overlayfs-when-copying-up-and-reading-d.patch"
SRC_URI += "file://0087-UBUNTU-SAUCE-overlayfs-Enable-user-namespace-mounts-.patch"
SRC_URI += "file://0088-UBUNTU-SAUCE-Add-vmlinux.strip-to-BOOT_TARGETS1.patch"
SRC_URI += "file://0089-UBUNTU-SAUCE-no-up-apparmor-add-parameter-to-control.patch"
SRC_URI += "file://0090-UBUNTU-SAUCE-no-up-apparmor-Sync-to-apparmor3-RC1-sn.patch"
SRC_URI += "file://0091-UBUNTU-SAUCE-Revert-fix-only-allow-a-single-threaded.patch"
SRC_URI += "file://0092-UBUNTU-SAUCE-no-up-fix-bad-unix_addr_fs-macro.patch"
SRC_URI += "file://0093-UBUNTU-apparmor-follow-change-to-this_cpu_ptr.patch"
SRC_URI += "file://0094-UBUNTU-SAUCE-no-up-apparmor-fix-mediation-of-fs-unix.patch"
SRC_URI += "file://0095-UBUNTU-SAUCE-no-up-apparmor-fix-mount-not-handling-d.patch"
SRC_URI += "file://0096-UBUNTU-SAUCE-leds-lp55xx-do-not-force-use-of-the-fal.patch"
SRC_URI += "file://0097-Revert-UBUNTU-SAUCE-noup-crypto-842-Add-CRC-and-vali.patch"
SRC_URI += "file://0098-UBUNTU-SAUCE-noup-cxlflash-Fix-to-escalate-LINK_RESE.patch"
SRC_URI += "file://0099-UBUNTU-SAUCE-noup-cxlflash-Fix-to-avoid-virtual-LUN-.patch"
SRC_URI += "file://0100-UBUNTU-SAUCE-noup-cxlflash-a-couple-off-by-one-bugs.patch"
SRC_URI += "file://0101-UBUNTU-SAUCE-fan-add-VXLAN-implementation.patch"
SRC_URI += "file://0102-UBUNTU-SAUCE-AUFS.patch"
SRC_URI += "file://0103-UBUNTU-SAUCE-noup-ptrace-being-capable-wrt-a-process.patch"
SRC_URI += "file://0104-UBUNTU-SAUCE-crypto-nx-842-Mask-XERS0-bit-in-return-.patch"
SRC_URI += "file://0105-UBUNTU-SAUCE-add-a-sysctl-to-disable-unprivileged-us.patch"
SRC_URI += "file://0106-UBUNTU-SAUCE-no-up-apparmor-Fix-incompatible-pointer.patch"
SRC_URI += "file://0107-UBUNTU-SAUCE-radeon-r100-Silence-may-be-used-uniniti.patch"
SRC_URI += "file://0108-UBUNTU-SAUCE-dmaengine-ioatdma-Squelch-framesize-war.patch"
SRC_URI += "file://0109-UBUNTU-SAUCE-no-up-udp-properly-support-MSG_PEEK-wit.patch"
SRC_URI += "file://0110-Revert-UBUNTU-SAUCE-AUFS.patch"
SRC_URI += "file://0111-UBUNTU-SAUCE-AUFS.patch"
SRC_URI += "file://0112-perf-x86-intel-uncore-Add-Broadwell-EP-uncore-suppor.patch"
SRC_URI += "file://0113-EDAC-Add-DDR4-flag.patch"
SRC_URI += "file://0114-EDAC-sb_edac-Virtualize-several-hard-coded-functions.patch"
SRC_URI += "file://0115-EDAC-sb_edac-Add-support-for-duplicate-device-IDs.patch"
SRC_URI += "file://0116-EDAC-sb_edac-Add-Knights-Landing-Xeon-Phi-gen-2-supp.patch"
SRC_URI += "file://0117-Driver-for-IBM-System-i-p-VNIC-protocol.patch"
SRC_URI += "file://0118-UBUNTU-SAUCE-no-up-add-compat_uts_machine-kernel-com.patch"
SRC_URI += "file://0119-Revert-SCSI-libiscsi-Reduce-locking-contention-in-fa.patch"
SRC_URI += "file://0120-UBUNTU-SAUCE-ACPI-tables-Add-acpi_force_32bit_fadt_a.patch"
#SRC_URI += "file://0121-UBUNTU-SAUCE-no-up-Update-bnx2x-firmware-to-7.12.30..patch"
#SRC_URI += "file://0122-UBUNTU-SAUCE-drop-obsolete-bnx2x-firmware.patch"
SRC_URI += "file://0123-i40evf-fix-compiler-warning-of-unused-variable.patch"
SRC_URI += "file://0124-intel-i40e-fix-confused-code.patch"
SRC_URI += "file://0125-i40e-i40evf-remove-unused-tunnel-parameter.patch"
SRC_URI += "file://0126-i40e-Change-BUG_ON-to-WARN_ON-in-service-event-compl.patch"
SRC_URI += "file://0127-i40e-remove-BUG_ON-from-feature-string-building.patch"
SRC_URI += "file://0128-i40e-remove-BUG_ON-from-FCoE-setup.patch"
SRC_URI += "file://0129-i40e-Workaround-fix-for-mss-256-issue.patch"
SRC_URI += "file://0130-i40e-i40evf-Add-a-stat-to-track-how-many-times-we-ha.patch"
SRC_URI += "file://0131-i40e-Move-the-saving-of-old-link-info-from-handle_li.patch"
SRC_URI += "file://0132-i40e-i40evf-Add-comment-to-endif.patch"
SRC_URI += "file://0133-i40e-i40evf-clean-up-error-messages.patch"
SRC_URI += "file://0134-i40evf-handle-many-MAC-filters-correctly.patch"
SRC_URI += "file://0135-i40e-return-the-number-of-enabled-queues-for-ETHTOOL.patch"
SRC_URI += "file://0136-i40e-rework-the-functions-to-configure-RSS-with-simi.patch"
SRC_URI += "file://0137-i40e-create-a-generic-configure-rss-function.patch"
SRC_URI += "file://0138-i40e-Bump-version-to-1.4.2.patch"
SRC_URI += "file://0139-i40e-add-new-fields-to-store-user-configuration.patch"
SRC_URI += "file://0140-i40e-rename-rss_size-to-alloc_rss_size-in-i40e_pf.patch"
SRC_URI += "file://0141-i40e-i40evf-Fix-RS-bit-update-in-Tx-path-and-disable.patch"
SRC_URI += "file://0142-i40e-i40evf-prefetch-skb-data-on-transmit.patch"
SRC_URI += "file://0143-i40evf-rename-VF-adapter-specific-RSS-function.patch"
SRC_URI += "file://0144-i40evf-create-a-generic-config-RSS-function.patch"
SRC_URI += "file://0145-i40evf-create-a-generic-get-RSS-function.patch"
SRC_URI += "file://0146-i40evf-add-new-fields-to-store-user-configuration-of.patch"
SRC_URI += "file://0147-i40e-Update-error-messaging.patch"
SRC_URI += "file://0148-i40e-fix-confusing-message.patch"
SRC_URI += "file://0149-i40e-make-error-message-more-useful.patch"
SRC_URI += "file://0150-i40evf-quoth-the-VF-driver-Nevermore.patch"
SRC_URI += "file://0151-i40evf-allocate-queue-vectors-dynamically.patch"
SRC_URI += "file://0152-i40evf-allocate-ring-structs-dynamically.patch"
SRC_URI += "file://0153-i40e-i40evf-Bump-i40e-version-to-1.4.4-and-i40evf-to.patch"
SRC_URI += "file://0154-i40e-fix-do-not-sleep-in-netdev_ops.patch"
SRC_URI += "file://0155-i40e-remove-unused-argument.patch"
SRC_URI += "file://0156-i40evf-increase-max-number-of-queues.patch"
SRC_URI += "file://0157-i40evf-set-real-num-queues.patch"
SRC_URI += "file://0158-i40evf-remove-duplicate-string.patch"
SRC_URI += "file://0159-i40e-Detection-and-recovery-of-TX-queue-hung-logic-m.patch"
SRC_URI += "file://0160-i40e-Fix-memory-leaks-sideband-filter-programming.patch"
SRC_URI += "file://0161-i40evf-don-t-use-atomic-allocation.patch"
SRC_URI += "file://0162-i40e-propagate-properly.patch"
SRC_URI += "file://0163-i40evf-use-correct-types.patch"
SRC_URI += "file://0164-i40e-use-priv-flags-to-control-packet-split.patch"
SRC_URI += "file://0165-i40e-remove-CONFIG_I40E_VXLAN.patch"
SRC_URI += "file://0166-i40e-Remove-separate-functions-gathering-XOFF-Rx-sta.patch"
SRC_URI += "file://0167-i40e-fix-whitespace.patch"
SRC_URI += "file://0168-i40e-i40evf-use-logical-operator.patch"
SRC_URI += "file://0169-i40e-i40evf-Bump-version-to-1.4.7-for-i40e-and-1.4.3.patch"
SRC_URI += "file://0170-i40e-trivial-fixes.patch"
SRC_URI += "file://0171-i40e-Fix-i40e_print_features-VEB-mode-output.patch"
SRC_URI += "file://0172-Revert-i40e-remove-CONFIG_I40E_VXLAN.patch"
SRC_URI += "file://0173-i40e-chomp-the-BIT-_ULL.patch"
SRC_URI += "file://0174-i40e-properly-delete-VF-MAC-filters.patch"
SRC_URI += "file://0175-i40e-don-t-add-zero-MAC-filter.patch"
SRC_URI += "file://0176-i40evf-check-rings-before-freeing-resources.patch"
SRC_URI += "file://0177-i40e-use-explicit-cast-from-u16-to-u8.patch"
SRC_URI += "file://0178-i40e-Opcode-and-structures-required-by-OEM-Post-Upda.patch"
SRC_URI += "file://0179-i40e-hush-little-warnings.patch"
SRC_URI += "file://0180-i40e-i40evf-Add-a-new-offload-for-RSS-PCTYPE-V2-for-.patch"
SRC_URI += "file://0181-i40e-clean-whole-mac-filter-list.patch"
SRC_URI += "file://0182-i40evf-change-version-string-generation.patch"
SRC_URI += "file://0183-i40e-i40evf-Bump-i40e-to-1.4.8-and-i40evf-to-1.4.4.patch"
SRC_URI += "file://0184-geneve-UDP-checksum-configuration-via-netlink.patch"
SRC_URI += "file://0185-geneve-Add-geneve-udp-port-offload-for-ethernet-devi.patch"
SRC_URI += "file://0186-i40e-geneve-tunnel-offload-support.patch"
SRC_URI += "file://0187-geneve-Add-geneve_get_rx_port-support.patch"
SRC_URI += "file://0188-i40e-Call-geneve_get_rx_port-to-get-the-existing-Gen.patch"
SRC_URI += "file://0189-i40e-change-log-messages-and-error-returns.patch"
SRC_URI += "file://0190-i40e-allow-zero-MAC-address-for-VFs.patch"
SRC_URI += "file://0191-i40e-Look-up-MAC-address-in-Open-Firmware-or-IDPROM.patch"
SRC_URI += "file://0192-i40e-Fix-Rx-hash-reported-to-the-stack-by-our-driver.patch"
SRC_URI += "file://0193-i40e-remove-forever-unused-ID.patch"
SRC_URI += "file://0194-igb-add-88E1543-initialization-code.patch"
SRC_URI += "file://0195-igb-don-t-unmap-NULL-hw_addr.patch"
SRC_URI += "file://0196-igb-use-the-correct-i210-register-for-EEMNGCTL.patch"
SRC_URI += "file://0197-igb-fix-NULL-derefs-due-to-skipped-SR-IOV-enabling.patch"
SRC_URI += "file://0198-igb-improve-handling-of-disconnected-adapters.patch"
SRC_URI += "file://0199-igb-Remove-GS40G-specific-defines-functions.patch"
SRC_URI += "file://0200-igb-Don-t-add-PHY-address-to-PCDL-address.patch"
SRC_URI += "file://0201-igb-Improve-cable-length-function-for-I210-etc.patch"
SRC_URI += "file://0202-igb-Explicitly-label-self-test-result-indices.patch"
SRC_URI += "file://0203-ixgbe-drop-null-test-before-destroy-functions.patch"
SRC_URI += "file://0204-ixgbe-Delete-redundant-include-file.patch"
SRC_URI += "file://0205-ixgbe-fix-multiple-kernel-doc-errors.patch"
SRC_URI += "file://0206-ixgbe-Fix-handling-of-NAPI-budget-when-multiple-queu.patch"
SRC_URI += "file://0207-ixgbe-Add-KR-mode-support-for-CS4227-chip.patch"
SRC_URI += "file://0208-ixgbevf-Limit-lowest-interrupt-rate-for-adaptive-int.patch"
SRC_URI += "file://0209-ixgbe-ixgbevf-use-napi_schedule_irqoff.patch"
SRC_URI += "file://0210-ixgbe-Remove-CS4227-diagnostic-code.patch"
SRC_URI += "file://0211-ixgbevf-use-ether_addr_copy-instead-of-memcpy.patch"
SRC_URI += "file://0212-ixgbevf-fix-spoofed-packets-with-random-MAC.patch"
SRC_URI += "file://0213-ixgbe-Prevent-KR-PHY-reset-in-ixgbe_init_phy_ops_x55.patch"
SRC_URI += "file://0214-ixgbe-Add-support-for-newer-thermal-alarm.patch"
SRC_URI += "file://0215-ixgbe-Use-private-workqueue-to-avoid-certain-possibl.patch"
SRC_URI += "file://0216-ixgbevf-Use-a-private-workqueue-to-avoid-certain-pos.patch"
SRC_URI += "file://0217-ixgbevf-Minor-cleanups.patch"
SRC_URI += "file://0218-ixgbe-Refactor-MAC-address-configuration-code.patch"
SRC_URI += "file://0219-ixgbe-Use-__dev_uc_sync-and-__dev_uc_unsync-for-unic.patch"
SRC_URI += "file://0220-ixgbe-Allow-FDB-entries-access-to-more-RAR-filters.patch"
SRC_URI += "file://0221-ixgbe-Update-PTP-to-support-X550EM_x-devices.patch"
SRC_URI += "file://0222-ixgbe-Correct-spec-violations-by-waiting-after-reset.patch"
SRC_URI += "file://0223-ixgbe-Wait-for-master-disable-to-be-set.patch"
SRC_URI += "file://0224-ixgbe-Save-VF-info-and-take-references.patch"
SRC_URI += "file://0225-ixgbe-Handle-extended-IPv6-headers-in-Tx-path.patch"
SRC_URI += "file://0226-ixgbe-Always-turn-PHY-power-on-when-requested.patch"
SRC_URI += "file://0227-ixgbevf-Handle-extended-IPv6-headers-in-Tx-path.patch"
SRC_URI += "file://0228-ixgbe-Return-error-on-failure-to-allocate-mac_table.patch"
SRC_URI += "file://0229-ixgbe-Fix-SR-IOV-VLAN-pool-configuration.patch"
SRC_URI += "file://0230-ixgbe-Simplify-definitions-for-regidx-and-bit-in-set.patch"
SRC_URI += "file://0231-ixgbe-Reduce-VT-code-indent-in-set_vfta-by-introduci.patch"
SRC_URI += "file://0232-ixgbe-Simplify-configuration-of-setting-VLVF-and-VLV.patch"
SRC_URI += "file://0233-ixgbe-Add-support-for-adding-removing-VLAN-on-PF-byp.patch"
SRC_URI += "file://0234-ixgbe-Reorder-search-to-work-from-the-top-down-inste.patch"
SRC_URI += "file://0235-ixgbe-Add-support-for-VLAN-promiscuous-with-SR-IOV.patch"
SRC_URI += "file://0236-ixgbe-Fix-VLAN-promisc-in-relation-to-SR-IOV.patch"
SRC_URI += "file://0237-ixgbe-Clear-stale-pool-mappings.patch"
SRC_URI += "file://0238-ixgbe-Clean-stale-VLANs-when-changing-port-VLAN-or-r.patch"
SRC_URI += "file://0239-ixgbe-do-not-report-2.5-Gbps-as-supported.patch"
SRC_URI += "file://0240-ixgbevf-Fix-handling-of-NAPI-budget-when-multiple-qu.patch"
SRC_URI += "file://0241-ixgbevf-minor-cleanups-for-ixgbevf_set_itr.patch"
SRC_URI += "file://0242-ixgbe-add-support-for-QSFP-PHY-types-in-ixgbe_get_se.patch"
SRC_URI += "file://0243-ixgbe-report-correct-media-type-for-KR-KX-and-KX4-in.patch"
SRC_URI += "file://0244-ixgbe-Clean-up-redundancy-in-hw_enc_features.patch"
SRC_URI += "file://0245-ixgbe-fix-RSS-limit-for-X550.patch"
SRC_URI += "file://0246-ixgbe-Correct-X550EM_x-revision-check.patch"
SRC_URI += "file://0247-ixgbe-Fix-bugs-in-ixgbe_clear_vf_vlans.patch"
SRC_URI += "file://0248-ixgbe-Fill-at-least-min-credits-to-a-TC-credit-refil.patch"
SRC_URI += "file://0249-ixgbe-use-correct-FCoE-DDP-max-check.patch"
SRC_URI += "file://0250-ixgbe-fix-broken-PFC-with-X550.patch"
SRC_URI += "file://0251-ixgbe-do-not-call-check_link-for-ethtool-in-ixgbe_ge.patch"
SRC_URI += "file://0252-ixgbe-Correct-handling-of-any-outer-UDP-checksum-set.patch"
SRC_URI += "file://0253-ixgbe-Fix-to-get-FDMI-HBA-attributes-information-wit.patch"
SRC_URI += "file://0254-ixgbe-Fix-MDD-events-generated-when-FCoE-SRIOV-are-e.patch"
SRC_URI += "file://0255-ixgbe-Make-ATR-recognize-IPv6-extended-headers.patch"
SRC_URI += "file://0256-e1000-make-eeprom-read-write-scheduler-friendly.patch"
SRC_URI += "file://0257-e1000-fix-data-race-between-tx_ring-next_to_clean.patch"
SRC_URI += "file://0258-e1000-Remove-checkpatch-coding-style-errors.patch"
SRC_URI += "file://0259-e1000-clean-up-the-checking-logic.patch"
SRC_URI += "file://0260-e1000-fix-a-typo-in-the-comment.patch"
SRC_URI += "file://0261-e1000e-clean-up-the-local-variable.patch"
SRC_URI += "file://0262-e1000-fix-kernel-doc-argument-being-missing.patch"
SRC_URI += "file://0263-e1000-get-rid-of-duplicate-exit-path.patch"
SRC_URI += "file://0264-e1000-Elementary-checkpatch-warnings-and-checks-remo.patch"
SRC_URI += "file://0265-e1000e-fix-division-by-zero-on-jumbo-MTUs.patch"
SRC_URI += "file://0266-e1000e-Increase-timeout-of-polling-bit-RSPCIPHY.patch"
SRC_URI += "file://0267-e1000e-initial-support-for-i219-LM-3.patch"
SRC_URI += "file://0268-e1000e-Switch-e1000e_up-to-void-drop-code-checking-f.patch"
SRC_URI += "file://0269-e1000e-Remove-unreachable-code.patch"
SRC_URI += "file://0270-e1000e-Do-not-read-ICR-in-Other-interrupt.patch"
SRC_URI += "file://0271-e1000e-Do-not-write-lsc-to-ics-in-msi-x-mode.patch"
SRC_URI += "file://0272-e1000e-Fix-msi-x-interrupt-automask.patch"
SRC_URI += "file://0273-UBUNTU-SAUCE-arm64-errata-Add-mpc-relative-literal-l.patch"
SRC_URI += "file://0274-acpi-pci-Setup-MSI-domain-for-ACPI-based-pci-devices.patch"
SRC_URI += "file://0275-irqdomain-Introduce-is_fwnode_irqchip-helper.patch"
SRC_URI += "file://0276-irqchip-gic-v2m-Refactor-to-prepare-for-ACPI-support.patch"
SRC_URI += "file://0277-irqchip-gic-v2m-acpi-Introducing-GICv2m-ACPI-support.patch"
SRC_URI += "file://0278-clk-xgene-Fix-divider-with-non-zero-shift-value.patch"
SRC_URI += "file://0279-i2c-designware-Do-not-require-clock-when-SSCN-and-FF.patch"
SRC_URI += "file://0280-fm10k-do-not-assume-VF-always-has-1-queue.patch"
SRC_URI += "file://0281-fm10k-Correct-MTU-for-jumbo-frames.patch"
SRC_URI += "file://0282-fm10k-Fix-handling-of-NAPI-budget-when-multiple-queu.patch"
SRC_URI += "file://0283-fm10k-use-napi_schedule_irqoff.patch"
SRC_URI += "file://0284-fm10k-set-netdev-features-in-one-location.patch"
SRC_URI += "file://0285-fm10k-reset-max_queues-on-init_hw_vf-failure.patch"
SRC_URI += "file://0286-fm10k-always-check-init_hw-for-errors.patch"
SRC_URI += "file://0287-fm10k-reinitialize-queuing-scheme-after-calling-init.patch"
SRC_URI += "file://0288-fm10k-Correct-typecast-in-fm10k_update_xc_addr_pf.patch"
SRC_URI += "file://0289-fm10k-explicitly-typecast-vlan-values-to-u16.patch"
SRC_URI += "file://0290-fm10k-add-statistics-for-actual-DWORD-count-of-mbmem.patch"
SRC_URI += "file://0291-fm10k-rename-mbx_tx_oversized-statistic-to-mbx_tx_dr.patch"
SRC_URI += "file://0292-fm10k-Add-support-for-ITR-scaling-based-on-PCIe-link.patch"
SRC_URI += "file://0293-fm10k-introduce-ITR_IS_ADAPTIVE-macro.patch"
SRC_URI += "file://0294-fm10k-Update-adaptive-ITR-algorithm.patch"
SRC_URI += "file://0295-fm10k-use-macro-for-default-Tx-and-Rx-ITR-values.patch"
SRC_URI += "file://0296-fm10k-change-default-Tx-ITR-to-25usec.patch"
SRC_URI += "file://0297-fm10k-TRIVIAL-fix-typo-of-hardware.patch"
SRC_URI += "file://0298-fm10k-TRIVIAL-cleanup-order-at-top-of-fm10k_xmit_fra.patch"
SRC_URI += "file://0299-fm10k-use-ether_addr_copy-to-copy-MAC-address.patch"
SRC_URI += "file://0300-fm10k-do-not-use-CamelCase.patch"
SRC_URI += "file://0301-fm10k-remove-unnecessary-else-block-from-if-statemen.patch"
SRC_URI += "file://0302-fm10k-remove-namespace-pollution-of-fm10k_iov_msg_da.patch"
SRC_URI += "file://0303-fm10k-consistently-refer-to-VLANs-and-VLAN-IDs.patch"
SRC_URI += "file://0304-fm10k-bump-driver-version.patch"
SRC_URI += "file://0305-fm10k-conditionally-compile-DCB-and-DebugFS-support.patch"
SRC_URI += "file://0306-fm10k-Cleanup-MSI-X-interrupts-in-case-of-failure.patch"
SRC_URI += "file://0307-fm10k-Cleanup-exception-handling-for-mailbox-interru.patch"
SRC_URI += "file://0308-fm10k-do-not-inline-fm10k_iov_select_vid.patch"
SRC_URI += "file://0309-fm10k-whitespace-cleanups.patch"
SRC_URI += "file://0310-fm10k-use-BIT-macro-instead-of-open-coded-bit-shifti.patch"
SRC_URI += "file://0311-fm10k-cleanup-namespace-pollution.patch"
SRC_URI += "file://0312-fm10k-cleanup-overly-long-lines.patch"
SRC_URI += "file://0313-fm10k-initialize-xps-at-driver-load.patch"
SRC_URI += "file://0314-fm10k-don-t-initialize-fm10k_workqueue-at-global-lev.patch"
SRC_URI += "file://0315-fm10k-correctly-pack-TLV-structures-and-explain-reas.patch"
SRC_URI += "file://0316-fm10k-Cleanup-exception-handling-for-changing-queues.patch"
SRC_URI += "file://0317-fm10k-use-ether_addr_equal-instead-of-memcmp.patch"
SRC_URI += "file://0318-fm10k-address-operator-not-needed-when-declaring-fun.patch"
SRC_URI += "file://0319-fm10k-constify-fm10k_mac_ops-fm10k_iov_ops-and-fm10k.patch"
SRC_URI += "file://0320-fm10k-remove-unused-struct-element.patch"
SRC_URI += "file://0321-fm10k-use-true-false-for-boolean-get_host_state.patch"
SRC_URI += "file://0322-fm10k-cleanup-mailbox-code-comments-etc.patch"
SRC_URI += "file://0323-fm10k-IS_ENABLED-is-not-appropriate-for-boolean-kcon.patch"
SRC_URI += "file://0324-UBUNTU-SAUCE-no-up-apparmor-fix-for-failed-mediation.patch"
SRC_URI += "file://0325-UBUNTU-SAUCE-Powernv-Remove-the-usage-of-PACAR1-from.patch"
SRC_URI += "file://0326-UBUNTU-SAUCE-KVM-PPC-Book3S-HV-Fix-soft-lockups-in-K.patch"
SRC_URI += "file://0327-device-property-always-check-for-fwnode-type.patch"
SRC_URI += "file://0328-device-property-rename-helper-functions.patch"
SRC_URI += "file://0329-device-property-refactor-built-in-properties-support.patch"
SRC_URI += "file://0330-device-property-keep-single-value-inplace.patch"
SRC_URI += "file://0331-device-property-helper-macros-for-property-entry-cre.patch"
SRC_URI += "file://0332-device-property-improve-readability-of-macros.patch"
SRC_URI += "file://0333-device-property-return-EINVAL-when-property-isn-t-fo.patch"
SRC_URI += "file://0334-device-property-Fallback-to-secondary-fwnode-if-prim.patch"
SRC_URI += "file://0335-device-property-Take-a-copy-of-the-property-set.patch"
SRC_URI += "file://0336-driver-core-platform-Add-support-for-built-in-device.patch"
SRC_URI += "file://0337-driver-core-Do-not-overwrite-secondary-fwnode-with-N.patch"
SRC_URI += "file://0338-mfd-core-propagate-device-properties-to-sub-devices-.patch"
SRC_URI += "file://0339-mfd-intel-lpss-Add-support-for-passing-device-proper.patch"
SRC_URI += "file://0340-mfd-intel-lpss-Pass-SDA-hold-time-to-I2C-host-contro.patch"
SRC_URI += "file://0341-mfd-intel-lpss-Pass-HSUART-configuration-via-propert.patch"
SRC_URI += "file://0342-i2c-designware-Convert-to-use-unified-device-propert.patch"
SRC_URI += "file://0343-keys-trusted-fix-do-not-allow-duplicate-key-options.patch"
SRC_URI += "file://0344-keys-trusted-select-hash-algorithm-for-TPM2-chips.patch"
SRC_URI += "file://0345-keys-trusted-seal-with-a-TPM2-authorization-policy.patch"
SRC_URI += "file://0346-perf-x86-intel-Add-perf-core-PMU-support-for-Intel-K.patch"
SRC_URI += "file://0347-perf-x86-intel-uncore-Add-Knights-Landing-uncore-PMU.patch"
SRC_URI += "file://0348-perf-x86-intel-uncore-Remove-hard-coding-of-PMON-box.patch"
SRC_URI += "file://0349-drm-i915-WaRsDisableCoarsePowerGating.patch"
SRC_URI += "file://0350-drm-i915-skl-Add-SKL-GT4-PCI-IDs.patch"
SRC_URI += "file://0351-drm-i915-skl-Disable-coarse-power-gating-up-until-F0.patch"
SRC_URI += "file://0352-platform-x86-add-Intel-P-Unit-mailbox-IPC-driver.patch"
SRC_URI += "file://0353-intel_punit_ipc-add-NULL-check-for-input-parameters.patch"
SRC_URI += "file://0354-platform-x86-Add-Intel-Telemetry-Core-Driver.patch"
SRC_URI += "file://0355-intel_pmc_ipc-update-acpi-resource-structure-for-Pun.patch"
SRC_URI += "file://0356-platform-x86-Add-Intel-telemetry-platform-device.patch"
SRC_URI += "file://0357-platform-x86-Add-Intel-telemetry-platform-driver.patch"
SRC_URI += "file://0358-platform-x86-Add-Intel-Telemetry-Debugfs-interfaces.patch"
SRC_URI += "file://0359-Revert-UBUNTU-SAUCE-noup-cxlflash-a-couple-off-by-on.patch"
SRC_URI += "file://0360-cxlflash-a-couple-off-by-one-bugs.patch"
SRC_URI += "file://0361-UBUNTU-SAUCE-dm-introduce-a-target_ioctl-op-to-allow.patch"
SRC_URI += "file://0362-Revert-UBUNTU-SAUCE-dm-introduce-a-target_ioctl-op-t.patch"
SRC_URI += "file://0363-lightnvm-fix-bio-submission-issue.patch"
SRC_URI += "file://0364-lightnvm-fix-incorrect-nr_free_blocks-stat.patch"
SRC_URI += "file://0365-lightnvm-add-check-after-mempool-allocation.patch"
SRC_URI += "file://0366-lightnvm-unlock-rq-and-free-ppa_list-on-submission-f.patch"
SRC_URI += "file://0367-lightnvm-move-ppa-erase-logic-to-core.patch"
SRC_URI += "file://0368-lightnvm-refactor-rqd-ppa-list-into-set-free.patch"
SRC_URI += "file://0369-lightnvm-refactor-end_io-functions-for-sync.patch"
SRC_URI += "file://0370-lightnvm-return-the-get_bb_tbl-return-value.patch"
SRC_URI += "file://0371-lightnvm-check-bi_error-in-gc.patch"
SRC_URI += "file://0372-lightnvm-put-block-back-to-gc-list-on-its-reclaim-fa.patch"
SRC_URI += "file://0373-lightnvm-fix-locking-and-mempool-in-rrpc_lun_gc.patch"
SRC_URI += "file://0374-lightnvm-sectors-first-in-ppa-list.patch"
SRC_URI += "file://0375-lightnvm-move-the-pages-per-block-check-out-of-the-l.patch"
SRC_URI += "file://0376-lightnvm-support-multiple-ppas-in-nvm_erase_ppa.patch"
SRC_URI += "file://0377-lightnvm-move-rq-error-to-nvm_rq-error.patch"
SRC_URI += "file://0378-lightnvm-introduce-nvm_submit_ppa.patch"
SRC_URI += "file://0379-lightnvm-reference-rrpc-lun-in-rrpc-block.patch"
SRC_URI += "file://0380-lightnvm-fix-missing-grown-bad-block-type.patch"
SRC_URI += "file://0381-lightnvm-manage-open-and-closed-blocks-separately.patch"
SRC_URI += "file://0382-lightnvm-add-mccap-support.patch"
SRC_URI += "file://0383-lightnvm-introduce-mlc-lower-page-table-mappings.patch"
SRC_URI += "file://0384-lightnvm-core-on-disk-initialization.patch"
SRC_URI += "file://0385-lightnvm-introduce-ioctl-to-initialize-device.patch"
SRC_URI += "file://0386-lightnvm-use-system-block-for-mm-initialization.patch"
SRC_URI += "file://0387-lightnvm-introduce-factory-reset.patch"
SRC_URI += "file://0388-lightnvm-ensure-that-nvm_dev_ops-can-be-used-without.patch"
SRC_URI += "file://0389-blk-mq-add-a-flags-parameter-to-blk_mq_alloc_request.patch"
SRC_URI += "file://0390-nvme-move-struct-nvme_iod-to-pci.c.patch"
SRC_URI += "file://0391-nvme-split-command-submission-helpers-out-of-pci.c.patch"
SRC_URI += "file://0392-nvme-use-offset-instead-of-a-struct-for-registers.patch"
SRC_URI += "file://0393-nvme-split-nvme_trans_device_id_page.patch"
SRC_URI += "file://0394-nvme-use-vendor-it-from-identify.patch"
SRC_URI += "file://0395-nvme-split-a-new-struct-nvme_ctrl-out-of-struct-nvme.patch"
SRC_URI += "file://0396-nvme-simplify-nvme_setup_prps-calling-convention.patch"
SRC_URI += "file://0397-nvme-refactor-nvme_queue_rq.patch"
SRC_URI += "file://0398-nvme-factor-out-a-nvme_unmap_data-helper.patch"
SRC_URI += "file://0399-nvme-move-nvme_error_status-to-common-code.patch"
SRC_URI += "file://0400-nvme-move-nvme_setup_flush-and-nvme_setup_rw-to-comm.patch"
SRC_URI += "file://0401-nvme-split-__nvme_submit_sync_cmd.patch"
SRC_URI += "file://0402-nvme-use-the-block-layer-for-userspace-passthrough-m.patch"
SRC_URI += "file://0403-nvme-move-block_device_operations-and-ns-ctrl-freein.patch"
SRC_URI += "file://0404-nvme-add-explicit-quirk-handling.patch"
SRC_URI += "file://0405-nvme-move-remaining-CC-setup-into-nvme_enable_ctrl.patch"
SRC_URI += "file://0406-nvme-move-nvme_-enable-disable-shutdown-_ctrl-to-com.patch"
SRC_URI += "file://0407-nvme-add-a-common-helper-to-read-Identify-Controller.patch"
SRC_URI += "file://0408-nvme-move-the-call-to-nvme_init_identify-earlier.patch"
SRC_URI += "file://0409-nvme-move-namespace-scanning-to-common-code.patch"
SRC_URI += "file://0410-nvme-move-chardev-and-sysfs-interface-to-common-code.patch"
SRC_URI += "file://0411-nvme-refactor-set_queue_count.patch"
SRC_URI += "file://0412-blk-integrity-empty-implementation-when-disabled.patch"
SRC_URI += "file://0413-NVMe-fix-build-with-CONFIG_NVM-enabled.patch"
SRC_URI += "file://0414-nvme-fix-another-32-bit-build-warning.patch"
SRC_URI += "file://0415-nvme-precedence-bug-in-nvme_pr_clear.patch"
SRC_URI += "file://0416-nvme-only-ignore-hardware-errors-in-nvme_create_io_q.patch"
SRC_URI += "file://0417-nvme-only-add-a-controller-to-dev_list-after-it-s-be.patch"
SRC_URI += "file://0418-nvme-protect-against-simultaneous-shutdown-invocatio.patch"
SRC_URI += "file://0419-nvme-don-t-take-the-I-O-queue-q_lock-in-nvme_timeout.patch"
SRC_URI += "file://0420-nvme-merge-nvme_abort_req-and-nvme_timeout.patch"
SRC_URI += "file://0421-nvme-add-NVME_SC_CANCELLED.patch"
SRC_URI += "file://0422-nvme-simplify-resets.patch"
SRC_URI += "file://0423-nvme-do-not-restart-the-request-timeout-if-we-re-res.patch"
SRC_URI += "file://0424-nvme-merge-probe_work-and-reset_work.patch"
SRC_URI += "file://0425-nvme-remove-dead-controllers-from-a-work-item.patch"
SRC_URI += "file://0426-nvme-switch-abort_limit-to-an-atomic_t.patch"
SRC_URI += "file://0427-NVMe-Implement-namespace-list-scanning.patch"
SRC_URI += "file://0428-NVMe-Use-unbounded-work-queue-for-all-work.patch"
SRC_URI += "file://0429-NVMe-Remove-device-management-handles-on-remove.patch"
SRC_URI += "file://0430-NVMe-Simplify-metadata-setup.patch"
SRC_URI += "file://0431-nvme-fix-admin-queue-depth.patch"
SRC_URI += "file://0432-nvme-factor-out-a-few-helpers-from-req_completion.patch"
SRC_URI += "file://0433-nvme-switch-delete-SQ-CQ-to-blk_execute_rq_nowait.patch"
SRC_URI += "file://0434-nvme-switch-abort-to-blk_execute_rq_nowait.patch"
SRC_URI += "file://0435-nvme-special-case-AEN-requests.patch"
SRC_URI += "file://0436-nvme-simplify-completion-handling.patch"
SRC_URI += "file://0437-nvme-properly-free-resources-for-cancelled-command.patch"
SRC_URI += "file://0438-nvme-meta_sg-doesn-t-have-to-be-an-array.patch"
SRC_URI += "file://0439-nvme-merge-iod-and-cmd_info.patch"
SRC_URI += "file://0440-NVMe-Add-pci-error-handlers.patch"
SRC_URI += "file://0441-NVMe-Export-namespace-attributes-to-sysfs.patch"
SRC_URI += "file://0442-nvme-Move-nvme_freeze-unfreeze_queues-to-nvme-core.patch"
SRC_URI += "file://0443-nvme-synchronize-access-to-ctrl-namespaces.patch"
SRC_URI += "file://0444-nvme-fixes-for-NVME_IOCTL_IO_CMD-on-the-char-device.patch"
SRC_URI += "file://0445-nvme-make-SG_IO-support-optional.patch"
SRC_URI += "file://0446-NVMe-Fix-admin-queue-ring-wrap.patch"
SRC_URI += "file://0447-NVMe-Use-a-retryable-error-code-on-reset.patch"
SRC_URI += "file://0448-NVMe-Remove-queue-freezing-on-resets.patch"
SRC_URI += "file://0449-NVMe-IO-queue-deletion-re-write.patch"
SRC_URI += "file://0450-NVMe-Shutdown-controller-only-for-power-off.patch"
SRC_URI += "file://0451-NVMe-Export-NVMe-attributes-to-sysfs-group.patch"
SRC_URI += "file://0452-UBUNTU-SAUCE-nvme-merge-cleanup.patch"
SRC_URI += "file://0453-i40e-fix-build-warnings.patch"
SRC_URI += "file://0454-net-i40e-shut-up-uninitialized-variable-warnings.patch"
SRC_URI += "file://0455-tools-hv-report-ENOSPC-errors-in-hv_fcopy_daemon.patch"
SRC_URI += "file://0456-tools-hv-remove-repeated-HV_FCOPY-string.patch"
SRC_URI += "file://0457-drivers-hv-cleanup-synic-msrs-if-vmbus-connect-faile.patch"
SRC_URI += "file://0458-drivers-hv-Export-a-function-that-maps-Linux-CPU-num.patch"
SRC_URI += "file://0459-drivers-hv-Export-the-API-to-invoke-a-hypercall-on-H.patch"
SRC_URI += "file://0460-drivers-hv-Define-the-channel-type-for-Hyper-V-PCI-E.patch"
SRC_URI += "file://0461-drivers-hv-Allow-for-MMIO-claims-that-span-ACPI-_CRS.patch"
SRC_URI += "file://0462-drivers-hv-correct-tsc-page-sequence-invalid-value.patch"
SRC_URI += "file://0463-tools-hv-vss-fix-the-write-s-argument-error-vss_msg.patch"
SRC_URI += "file://0464-drivers-hv-replace-enum-hv_message_type-by-u32.patch"
SRC_URI += "file://0465-drivers-hv-Move-HV_SYNIC_STIMER_COUNT-into-Hyper-V-U.patch"
SRC_URI += "file://0466-drivers-hv-Move-struct-hv_message-into-UAPI-Hyper-V-.patch"
SRC_URI += "file://0467-drivers-hv-Move-struct-hv_timer_message_payload-into.patch"
SRC_URI += "file://0468-cxl-Fix-possible-idr-warning-when-contexts-are-relea.patch"
SRC_URI += "file://0469-cxl-use-correct-operator-when-writing-pcie-config-sp.patch"
SRC_URI += "file://0470-cxlflash-drop-unlikely-before-IS_ERR_OR_NULL.patch"
SRC_URI += "file://0471-cxl-Fix-DSI-misses-when-the-context-owning-task-exit.patch"
SRC_URI += "file://0472-cxlflash-Removed-driver-date-print.patch"
SRC_URI += "file://0473-cxlflash-Fix-to-resolve-cmd-leak-after-host-reset.patch"
SRC_URI += "file://0474-cxlflash-Resolve-oops-in-wait_port_offline.patch"
SRC_URI += "file://0475-cxlflash-Enable-device-id-for-future-IBM-CXL-adapter.patch"
SRC_URI += "file://0476-cxl-fix-build-for-GCC-4.6.x.patch"
SRC_URI += "file://0477-cxl-use-Werror-only-with-CONFIG_PPC_WERROR.patch"
SRC_URI += "file://0478-cxl-Enable-PCI-device-ID-for-future-IBM-CXL-adapter.patch"
SRC_URI += "file://0479-lpfc-Fix-FCF-Infinite-loop-in-lpfc_sli4_fcf_rr_next_.patch"
SRC_URI += "file://0480-lpfc-Fix-the-FLOGI-discovery-logic-to-comply-with-T1.patch"
SRC_URI += "file://0481-lpfc-Fix-RegLogin-failed-error-seen-on-Lancer-FC-dur.patch"
SRC_URI += "file://0482-lpfc-Fix-driver-crash-when-module-parameter-lpfc_fcp.patch"
SRC_URI += "file://0483-lpfc-Fix-crash-in-fcp-command-completion-path.patch"
SRC_URI += "file://0484-lpfc-Modularize-and-cleanup-FDMI-code-in-driver.patch"
SRC_URI += "file://0485-lpfc-Fix-RDP-Speed-reporting.patch"
SRC_URI += "file://0486-lpfc-Fix-RDP-ACC-being-too-long.patch"
SRC_URI += "file://0487-lpfc-Make-write-check-error-processing-more-resilien.patch"
SRC_URI += "file://0488-lpfc-Use-new-FDMI-speed-definitions-for-10G-25G-and-.patch"
SRC_URI += "file://0489-lpfc-Fix-mbox-reuse-in-PLOGI-completion.patch"
SRC_URI += "file://0490-lpfc-Fix-external-loopback-failure.patch"
SRC_URI += "file://0491-lpfc-Add-logging-for-misconfigured-optics.patch"
SRC_URI += "file://0492-lpfc-Delete-unnecessary-checks-before-the-function-c.patch"
SRC_URI += "file://0493-lpfc-Use-kzalloc-instead-of-kmalloc.patch"
SRC_URI += "file://0494-lpfc-Update-version-to-11.0.0.10-for-upstream-patch-.patch"
SRC_URI += "file://0495-x86-irq-Export-functions-to-allow-MSI-domains-in-mod.patch"
SRC_URI += "file://0496-genirq-msi-Export-functions-to-allow-MSI-domains-in-.patch"
SRC_URI += "file://0497-qla2xxx-Remove-unavailable-firmware-files.patch"
SRC_URI += "file://0498-qla2xxx-Enable-Extended-Logins-support.patch"
SRC_URI += "file://0499-qla2xxx-Enable-Exchange-offload-support.patch"
SRC_URI += "file://0500-qla2xxx-Enable-Target-counters-in-DebugFS.patch"
SRC_URI += "file://0501-qla2xxx-Add-FW-resource-count-in-DebugFS.patch"
SRC_URI += "file://0502-qla2xxx-Added-interface-to-send-explicit-LOGO.patch"
SRC_URI += "file://0503-qla2xxx-Delete-session-if-initiator-is-gone-from-FW.patch"
SRC_URI += "file://0504-qla2xxx-Wait-for-all-conflicts-before-ack-ing-PLOGI.patch"
SRC_URI += "file://0505-qla2xxx-Replace-QLA_TGT_STATE_ABORTED-with-a-bit.patch"
SRC_URI += "file://0506-qla2xxx-Remove-dependency-on-hardware_lock-to-reduce.patch"
SRC_URI += "file://0507-qla2xxx-Add-irq-affinity-notification.patch"
SRC_URI += "file://0508-qla2xxx-Add-selective-command-queuing.patch"
SRC_URI += "file://0509-qla2xxx-Move-atioq-to-a-different-lock-to-reduce-loc.patch"
SRC_URI += "file://0510-qla2xxx-Disable-ZIO-at-start-time.patch"
SRC_URI += "file://0511-qla2xxx-Set-all-queues-to-4k.patch"
SRC_URI += "file://0512-qla2xxx-Check-for-online-flag-instead-of-active-rese.patch"
SRC_URI += "file://0513-scsi-qla2xxxx-avoid-type-mismatch-in-comparison.patch"
SRC_URI += "file://0514-HID-multitouch-enable-palm-rejection-if-device-imple.patch"
SRC_URI += "file://0515-UBUNTU-SAUCE-IB-IPoIB-Do-not-set-skb-truesize-since-.patch"
SRC_URI += "file://0516-Revert-af_unix-Revert-lock_interruptible-in-stream-r.patch"
SRC_URI += "file://0517-Input-wacom_w8001-use-__set_bit-for-evbits.patch"
SRC_URI += "file://0518-Input-wacom_w8001-set-BTN_TOOL_DOUBLETAP-if-we-have-.patch"
SRC_URI += "file://0519-Input-wacom_w8001-handle-touch-error-case-correctly.patch"
SRC_URI += "file://0520-Input-wacom_w8001-split-pen-and-touch-initialization.patch"
SRC_URI += "file://0521-Input-wacom_w8001-split-the-touch-and-pen-devices-in.patch"
SRC_URI += "file://0522-Input-wacom_w8001-drop-use-of-ABS_MT_TOOL_TYPE.patch"
SRC_URI += "file://0523-net-mlx5_core-Modify-enable-disable-hca-functions.patch"
SRC_URI += "file://0524-net-mlx5_core-Add-base-sriov-support.patch"
SRC_URI += "file://0525-net-mlx5-Add-HW-capabilities-and-structs-for-SR-IOV-.patch"
SRC_URI += "file://0526-net-mlx5-Update-access-functions-to-Query-Modify-vpo.patch"
SRC_URI += "file://0527-net-mlx5-Introduce-access-functions-to-modify-query-.patch"
SRC_URI += "file://0528-net-mlx5-Introduce-access-functions-to-modify-query-.patch"
SRC_URI += "file://0529-net-mlx5-Introduce-access-functions-to-modify-query-.patch"
SRC_URI += "file://0530-net-mlx5-Introduce-access-functions-to-modify-query-.patch"
SRC_URI += "file://0531-net-mlx5e-Write-UC-MC-list-and-promisc-mode-into-vpo.patch"
SRC_URI += "file://0532-net-mlx5e-Write-vlan-list-into-vport-context.patch"
SRC_URI += "file://0533-net-mlx5-Introducing-E-Switch-and-l2-table.patch"
SRC_URI += "file://0534-net-mlx5-E-Switch-Introduce-FDB-hardware-capabilitie.patch"
SRC_URI += "file://0535-net-mlx5-E-Switch-Add-SR-IOV-FDB-support.patch"
SRC_URI += "file://0536-net-mlx5-E-Switch-Introduce-Vport-administration-fun.patch"
SRC_URI += "file://0537-net-mlx5-E-Switch-Introduce-HCA-cap-and-E-Switch-vpo.patch"
SRC_URI += "file://0538-net-mlx5-E-Switch-Introduce-set-vport-vlan-VST-mode.patch"
SRC_URI += "file://0539-net-mlx5-E-Switch-Introduce-get-vf-statistics.patch"
SRC_URI += "file://0540-net-mlx5e-Add-support-for-SR-IOV-ndos.patch"
SRC_URI += "file://0541-net-mlx5-Fix-query-E-Switch-capabilities.patch"
SRC_URI += "file://0542-net-mlx5e-Assign-random-MAC-address-if-needed.patch"
SRC_URI += "file://0543-UBUNTU-SAUCE-nbd-ratelimit-error-msgs-after-socket-c.patch"
SRC_URI += "file://0544-mm-CONFIG_NR_ZONES_EXTENDED.patch"
SRC_URI += "file://0545-qeth-initialize-net_device-with-carrier-off.patch"
SRC_URI += "file://0546-megaraid-Fix-possible-NULL-pointer-deference-in-mrai.patch"
SRC_URI += "file://0547-libahci-Implement-the-capability-to-override-the-gen.patch"
SRC_URI += "file://0548-ata-Remove-the-AHCI_HFLAG_EDGE_IRQ-support-from-liba.patch"
SRC_URI += "file://0549-ahci_xgene-Implement-the-workaround-to-fix-the-missi.patch"
SRC_URI += "file://0550-UBUNTU-SAUCE-storvsc-use-small-sg_tablesize-on-x86.patch"
SRC_URI += "file://0551-NTB-Add-support-for-AMD-PCI-Express-Non-Transparent-.patch"
SRC_URI += "file://0552-UBUNTU-SAUCE-fs-Add-user-namesapace-member-to-struct.patch"
SRC_URI += "file://0553-UBUNTU-SAUCE-fs-Limit-file-caps-to-the-user-namespac.patch"
SRC_URI += "file://0554-UBUNTU-SAUCE-Smack-Add-support-for-unprivileged-moun.patch"
SRC_URI += "file://0555-UBUNTU-SAUCE-block_dev-Support-checking-inode-permis.patch"
SRC_URI += "file://0556-UBUNTU-SAUCE-block_dev-Check-permissions-towards-blo.patch"
SRC_URI += "file://0557-UBUNTU-SAUCE-fs-Treat-foreign-mounts-as-nosuid.patch"
SRC_URI += "file://0558-UBUNTU-SAUCE-selinux-Add-support-for-unprivileged-mo.patch"
SRC_URI += "file://0559-UBUNTU-SAUCE-userns-Replace-in_userns-with-current_i.patch"
SRC_URI += "file://0560-UBUNTU-SAUCE-Smack-Handle-labels-consistently-in-unt.patch"
SRC_URI += "file://0561-UBUNTU-SAUCE-fs-Check-for-invalid-i_uid-in-may_follo.patch"
SRC_URI += "file://0562-UBUNTU-SAUCE-cred-Reject-inodes-with-invalid-ids-in-.patch"
SRC_URI += "file://0563-UBUNTU-SAUCE-fs-Refuse-uid-gid-changes-which-don-t-m.patch"
SRC_URI += "file://0564-UBUNTU-SAUCE-fs-Update-posix_acl-support-to-handle-u.patch"
SRC_URI += "file://0565-UBUNTU-SAUCE-fs-Ensure-the-mounter-of-a-filesystem-i.patch"
SRC_URI += "file://0566-UBUNTU-SAUCE-fs-Don-t-remove-suid-for-CAP_FSETID-in-.patch"
SRC_URI += "file://0567-UBUNTU-SAUCE-fs-Allow-superblock-owner-to-access-do_.patch"
SRC_URI += "file://0568-UBUNTU-SAUCE-capabilities-Allow-privileged-user-in-s.patch"
SRC_URI += "file://0569-UBUNTU-SAUCE-fuse-Add-support-for-pid-namespaces.patch"
SRC_URI += "file://0570-UBUNTU-SAUCE-fuse-Support-fuse-filesystems-outside-o.patch"
SRC_URI += "file://0571-UBUNTU-SAUCE-fuse-Restrict-allow_other-to-the-superb.patch"
SRC_URI += "file://0572-UBUNTU-SAUCE-fuse-Allow-user-namespace-mounts.patch"
SRC_URI += "file://0573-UBUNTU-SAUCE-mtd-Check-permissions-towards-mtd-block.patch"
SRC_URI += "file://0574-UBUNTU-SAUCE-fs-Update-i_-ug-id_-read-write-to-trans.patch"
SRC_URI += "file://0575-UBUNTU-SAUCE-quota-Convert-ids-relative-to-s_user_ns.patch"
SRC_URI += "file://0576-UBUNTU-SAUCE-evm-Translate-user-group-ids-relative-t.patch"
SRC_URI += "file://0577-UBUNTU-SAUCE-fs-Allow-CAP_SYS_ADMIN-in-s_user_ns-to-.patch"
SRC_URI += "file://0578-UBUNTU-SAUCE-quota-Treat-superblock-owner-as-privilg.patch"
SRC_URI += "file://0579-UBUNTU-SAUCE-ima-evm-Allow-root-in-s_user_ns-to-set-.patch"
SRC_URI += "file://0580-UBUNTU-SAUCE-block_dev-Forbid-unprivileged-mounting-.patch"
SRC_URI += "file://0581-UBUNTU-SAUCE-ext4-Add-support-for-unprivileged-mount.patch"
SRC_URI += "file://0582-UBUNTU-SAUCE-ext4-Add-module-parameter-to-enable-use.patch"
SRC_URI += "file://0583-UBUNTU-SAUCE-fuse-Add-module-parameter-to-enable-use.patch"
SRC_URI += "file://0584-megaraid_sas-Do-not-allow-PCI-access-during-OCR.patch"
SRC_URI += "file://0585-megaraid_sas-MFI-IO-timeout-handling.patch"
SRC_URI += "file://0586-megaraid_sas-Syncing-request-flags-macro-names-with-.patch"
SRC_URI += "file://0587-megaraid_sas-Task-management-support.patch"
SRC_URI += "file://0588-megaraid_sas-Update-device-queue-depth-based-on-inte.patch"
SRC_URI += "file://0589-megaraid_sas-Fastpath-region-lock-bypass.patch"
SRC_URI += "file://0590-megaraid_sas-Reply-Descriptor-Post-Queue-RDPQ-suppor.patch"
SRC_URI += "file://0591-megaraid_sas-Code-optimization-build_and_issue_cmd-r.patch"
SRC_URI += "file://0592-megaraid_sas-Dual-queue-depth-support.patch"
SRC_URI += "file://0593-megaraid_sas-IO-throttling-support.patch"
SRC_URI += "file://0594-megaraid_sas-Make-adprecovery-variable-atomic.patch"
SRC_URI += "file://0595-megaraid_sas-MFI-adapter-OCR-changes.patch"
SRC_URI += "file://0596-megaraid_sas-Introduce-module-parameter-for-SCSI-com.patch"
SRC_URI += "file://0597-megaraid_sas-SPERC-OCR-changes.patch"
SRC_URI += "file://0598-megaraid_sas-driver-version-upgrade.patch"
SRC_URI += "file://0599-megaraid-fix-null-pointer-check-in-megasas_detach_on.patch"
SRC_URI += "file://0600-megaraid_sas-Fix-for-IO-failing-post-OCR-in-SRIOV-en.patch"
SRC_URI += "file://0601-megaraid_sas-Fix-SMAP-issue.patch"
SRC_URI += "file://0602-megaraid_sas-Add-an-i-o-barrier.patch"
SRC_URI += "file://0603-openvswitch-allow-management-from-inside-user-namesp.patch"
SRC_URI += "file://0604-pwm-lpss-Remove-free-callback.patch"
SRC_URI += "file://0605-pwm-bcm2835-Calculate-scaler-in-config.patch"
SRC_URI += "file://0606-pwm-bcm2835-Prevent-division-by-zero.patch"
SRC_URI += "file://0607-pwm-bcm2835-Fix-email-address-specification.patch"
SRC_URI += "file://0608-pwm-lpss-Update-PWM-setting-for-Broxton.patch"
SRC_URI += "file://0609-pwm-lpss-Select-core-part-automatically.patch"
SRC_URI += "file://0610-pwm-lpss-Rework-the-sequence-of-programming-PWM_SW_U.patch"
SRC_URI += "file://0611-pwm-fsl-ftm-Fix-clock-enable-disable-when-using-PM.patch"
SRC_URI += "file://0612-pwm-lpc32xx-correct-number-of-PWM-channels-from-2-to.patch"
SRC_URI += "file://0613-pwm-lpc32xx-make-device-usable-with-common-clock-fra.patch"
SRC_URI += "file://0614-pwm-lpc32xx-fix-and-simplify-duty-cycle-and-period-c.patch"
SRC_URI += "file://0615-pwm-lpc32xx-return-ERANGE-if-requested-period-is-not.patch"
SRC_URI += "file://0616-pwm-rcar-Improve-accuracy-of-frequency-division-sett.patch"
SRC_URI += "file://0617-pwm-Add-PWM-driver-for-OMAP-using-dual-mode-timers.patch"
SRC_URI += "file://0618-pwm-add-HAS_IOMEM-dependency-to-PWM_FSL_FTM.patch"
SRC_URI += "file://0619-pwm-omap-dmtimer-Potential-NULL-dereference-on-error.patch"
SRC_URI += "file://0620-pwm-Mark-all-devices-as-might-sleep.patch"
SRC_URI += "file://0621-UBUNTU-SAUCE-noup-kernfs-Add-API-to-generate-relativ.patch"
SRC_URI += "file://0622-UBUNTU-SAUCE-noup-sched-new-clone-flag-CLONE_NEWCGRO.patch"
SRC_URI += "file://0623-UBUNTU-SAUCE-noup-cgroup-introduce-cgroup-namespaces.patch"
SRC_URI += "file://0624-UBUNTU-SAUCE-noup-cgroup-cgroup-namespace-setns-supp.patch"
SRC_URI += "file://0625-UBUNTU-SAUCE-noup-kernfs-define-kernfs_node_dentry.patch"
SRC_URI += "file://0626-UBUNTU-SAUCE-noup-cgroup-mount-cgroupns-root-when-in.patch"
SRC_URI += "file://0627-UBUNTU-SAUCE-noup-Add-FS_USERNS_FLAG-to-cgroup-fs.patch"
SRC_URI += "file://0628-UBUNTU-SAUCE-noup-cgroup-Add-documentation-for-cgrou.patch"
SRC_URI += "file://0629-net-thunderx-nicvf_queues-nivc_-_intr-remove-duplica.patch"
SRC_URI += "file://0630-net-thunderx-Remove-unnecessary-rcv-buffer-start-add.patch"
SRC_URI += "file://0631-net-thunderx-HW-TSO-support-for-pass-2-hardware.patch"
SRC_URI += "file://0632-net-thunderx-Enable-CQE-count-threshold-interrupt.patch"
SRC_URI += "file://0633-net-cavium-liquidio-use-helpers-ns_to_timespec64.patch"
SRC_URI += "file://0634-irqchip-gic-v3-Make-sure-read-from-ICC_IAR1_EL1-is-v.patch"
SRC_URI += "file://0635-arm64-KVM-Configure-TCR_EL2.PS-at-runtime.patch"
SRC_URI += "file://0636-arm64-prefetch-don-t-provide-spin_lock_prefetch-with.patch"
SRC_URI += "file://0637-arm64-prefetch-add-alternative-pattern-for-CPUs-with.patch"
SRC_URI += "file://0638-arm64-lib-improve-copy_page-to-deal-with-128-bytes-a.patch"
SRC_URI += "file://0639-arm64-lib-patch-in-prfm-for-copy_page-if-requested.patch"
SRC_URI += "file://0640-arm64-prefetch-add-missing-include-for-spin_lock_pre.patch"
SRC_URI += "file://0641-net-thunderx-Add-TX-timeout-and-RX-buffer-alloc-fail.patch"
SRC_URI += "file://0642-net-thunderx-Use-napi_schedule_irqoff.patch"
SRC_URI += "file://0643-net-thunderx-Assign-affinity-hints-to-vf-s-interrupt.patch"
SRC_URI += "file://0644-net-thunderx-bgx-Use-standard-firmware-node-infrastr.patch"
SRC_URI += "file://0645-net-thunderx-bgx-Add-log-message-when-setting-mac-ad.patch"
SRC_URI += "file://0646-net-thunderx-Alloc-higher-order-pages-when-pagesize-.patch"
SRC_URI += "file://0647-net-cavium-liquidio-Return-correct-error-code.patch"
SRC_URI += "file://0648-net-cavium-liquidio-fix-check-for-in-progress-flag.patch"
SRC_URI += "file://0649-livepatch-add-old_sympos-as-disambiguator-field-to-k.patch"
SRC_URI += "file://0650-livepatch-add-sympos-as-disambiguator-field-to-klp_r.patch"
SRC_URI += "file://0651-livepatch-function-sympos-scheme-in-livepatch-sysfs-.patch"
SRC_URI += "file://0652-module-Use-the-same-logic-for-setting-and-unsetting-.patch"
SRC_URI += "file://0653-gcov-use-within_module-helper.patch"
SRC_URI += "file://0654-module-use-a-structure-to-encapsulate-layout.patch"
SRC_URI += "file://0655-module-clean-up-RO-NX-handling.patch"
SRC_URI += "file://0656-module-keep-percpu-symbols-in-module-s-symtab.patch"
SRC_URI += "file://0657-livepatch-Cleanup-module-page-permission-changes.patch"
SRC_URI += "file://0658-arm64-kernel-implement-ACPI-parking-protocol.patch"
SRC_URI += "file://0659-ibmvscsi-Add-endian-conversions-to-sysfs-attribute-s.patch"
SRC_URI += "file://0660-mpt3sas-A-correction-in-unmap_resources.patch"
SRC_URI += "file://0661-mpt3sas-Added-support-for-high-port-count-HBA-varian.patch"
SRC_URI += "file://0662-mpt3sas-Used-IEEE-SGL-instead-of-MPI-SGL-while-frami.patch"
SRC_URI += "file://0663-mpt3sas-Fix-static-analyzer-coverity-tool-identified.patch"
SRC_URI += "file://0664-mpt3sas-Never-block-the-Enclosure-device.patch"
SRC_URI += "file://0665-mpt3sas-Make-use-of-additional-HighPriority-credit-m.patch"
SRC_URI += "file://0666-mpt3sas-Added-smp_affinity_enable-module-parameter.patch"
SRC_URI += "file://0667-mpt3sas-Add-support-for-configurable-Chain-Frame-Siz.patch"
SRC_URI += "file://0668-mpt3sas-Updated-MPI-Header-to-2.00.42.patch"
SRC_URI += "file://0669-mpt3sas-Fix-for-Asynchronous-completion-of-timedout-.patch"
SRC_URI += "file://0670-mpt3sas-Updating-mpt3sas-driver-version-to-12.100.00.patch"
SRC_URI += "file://0671-mpt3sas-Remove-cpumask_clear-for-zalloc_cpumask_var-.patch"
SRC_URI += "file://0672-net-bulk-free-infrastructure-for-NAPI-context-use-na.patch"
SRC_URI += "file://0673-net-Add-eth_platform_get_mac_address-helper.patch"
SRC_URI += "file://0674-i40e-Add-mac_filter_element-at-the-end-of-the-list-i.patch"
SRC_URI += "file://0675-i40e-i40evf-Fix-RSS-rx-flow-hash-configuration-throu.patch"
SRC_URI += "file://0676-i40e-Replace-X722-mac-check-in-ethtool-get_settings.patch"
SRC_URI += "file://0677-i40evf-allow-channel-bonding-of-VFs.patch"
SRC_URI += "file://0678-i40e-define-function-capabilities-in-only-one-place.patch"
SRC_URI += "file://0679-i40evf-null-out-ring-pointers-on-free.patch"
SRC_URI += "file://0680-i40e-Cleanup-the-code-with-respect-to-restarting-aut.patch"
SRC_URI += "file://0681-i40e-update-features-with-right-offload.patch"
SRC_URI += "file://0682-i40e-bump-version-to-1.4.10.patch"
SRC_URI += "file://0683-i40e-add-new-device-IDs-for-X722.patch"
SRC_URI += "file://0684-i40e-Extend-ethtool-RSS-hooks-for-X722.patch"
SRC_URI += "file://0685-i40e-i40evf-Fix-for-UDP-TCP-RSS-for-X722.patch"
SRC_URI += "file://0686-i40evf-add-new-write-back-mode.patch"
SRC_URI += "file://0687-i40e-i40evf-Use-private-workqueue.patch"
SRC_URI += "file://0688-i40e-add-new-proxy-wol-bit-for-X722.patch"
SRC_URI += "file://0689-i40e-Limit-DCB-FW-version-checks-to-X710-XL710-devic.patch"
SRC_URI += "file://0690-i40e-AQ-Add-Run-PHY-Activity-struct.patch"
SRC_URI += "file://0691-i40e-AQ-Geneve-cloud-tunnel-type.patch"
SRC_URI += "file://0692-i40e-AQ-Add-external-power-class-to-get-link-status.patch"
SRC_URI += "file://0693-i40e-add-100Mb-ethtool-reporting.patch"
SRC_URI += "file://0694-ixgbe-bulk-free-SKBs-during-TX-completion-cleanup-cy.patch"
SRC_URI += "file://0695-igb-Remove-unnecessary-flag-setting-in-igb_set_flag_.patch"
SRC_URI += "file://0696-igb-Unpair-the-queues-when-changing-the-number-of-qu.patch"
SRC_URI += "file://0697-igb-igbvf-don-t-give-up.patch"
SRC_URI += "file://0698-igb-clean-up-code-for-setting-MAC-address.patch"
SRC_URI += "file://0699-igb-Refactor-VFTA-configuration.patch"
SRC_URI += "file://0700-igb-Allow-asymmetric-configuration-of-MTU-versus-Rx-.patch"
SRC_URI += "file://0701-igb-Do-not-factor-VLANs-into-RLPML-calculation.patch"
SRC_URI += "file://0702-igb-Always-enable-VLAN-0-even-if-8021q-is-not-loaded.patch"
SRC_URI += "file://0703-igb-Merge-VLVF-configuration-into-igb_vfta_set.patch"
SRC_URI += "file://0704-igb-Clean-up-configuration-of-VF-port-VLANs.patch"
SRC_URI += "file://0705-igb-Add-support-for-VLAN-promiscuous-with-SR-IOV-and.patch"
SRC_URI += "file://0706-igb-Drop-unnecessary-checks-in-transmit-path.patch"
SRC_URI += "file://0707-igb-Enable-use-of-bridge-fdb-add-to-set-unicast-tabl.patch"
SRC_URI += "file://0708-igb-Add-workaround-for-VLAN-tag-stripping-on-82576.patch"
SRC_URI += "file://0709-i40e-AQ-Shared-resource-flags.patch"
SRC_URI += "file://0710-i40e-AQ-Add-set_switch_config.patch"
SRC_URI += "file://0711-i40e-AQ-Add-VXLAN-GPE-tunnel-type.patch"
SRC_URI += "file://0712-i40e-AQ-thermal-sensor-control-struct.patch"
SRC_URI += "file://0713-i40e-Bump-AQ-minor-version-to-1.5-for-new-FW-feature.patch"
SRC_URI += "file://0714-i40e-Store-lan_vsi_idx-and-lan_vsi_id-in-the-right-s.patch"
SRC_URI += "file://0715-i40e-fix-write-back-on-itr-to-work-with-legacy-itr.patch"
SRC_URI += "file://0716-i40e-add-counter-for-arq-overflows.patch"
SRC_URI += "file://0717-i40e-add-20G-speed-for-Tx-bandwidth-calculations.patch"
SRC_URI += "file://0718-i40e-refactor-DCB-function.patch"
SRC_URI += "file://0719-i40e-add-a-little-more-to-an-NVM-update-debug-messag.patch"
SRC_URI += "file://0720-i40evf-enable-bus-master-after-reset.patch"
SRC_URI += "file://0721-i40e-add-netdev-info-to-VSI-dump.patch"
SRC_URI += "file://0722-i40e-remove-VF-device-IDs-from-PF.patch"
SRC_URI += "file://0723-i40e-trivial-remove-unnecessary-local-var.patch"
SRC_URI += "file://0724-i40e-i40evf-Bump-i40e-to-1.4.11-and-i40evf-to-1.4.7.patch"
SRC_URI += "file://0725-net-ixgbe-add-minimal-parser-details-for-ixgbe.patch"
SRC_URI += "file://0726-i40e-trivial-drop-duplicate-definition.patch"
SRC_URI += "file://0727-i40e-trivial-fix-missing-space.patch"
SRC_URI += "file://0728-i40e-fix-bug-in-dma-sync.patch"
SRC_URI += "file://0729-i40e-do-TSO-only-if-CHECKSUM_PARTIAL-is-set.patch"
SRC_URI += "file://0730-i40e-allocate-memory-safer.patch"
SRC_URI += "file://0731-i40e-fix-do-not-sleep-in-netdev_ops.patch"
SRC_URI += "file://0732-i40e-APIs-to-Add-remove-port-mirroring-rules.patch"
SRC_URI += "file://0733-i40e-negate-PHY-int-mask-bits.patch"
SRC_URI += "file://0734-i40e-drop-unused-function.patch"
SRC_URI += "file://0735-i40e-count-allocation-errors.patch"
SRC_URI += "file://0736-i40e-avoid-large-memcpy-by-assigning-struct.patch"
SRC_URI += "file://0737-i40e-i40evf-bump-version-to-1.4.12-1.4.8.patch"
SRC_URI += "file://0738-i40e-Enable-Geneve-offload-for-FW-API-ver-1.4-for-XL.patch"
SRC_URI += "file://0739-i40e-add-priv-flag-for-automatic-rule-eviction.patch"
SRC_URI += "file://0740-i40e-use-eth_platform_get_mac_address.patch"
SRC_URI += "file://0741-i40e-move-sync_vsi_filters-up-in-service_task.patch"
SRC_URI += "file://0742-i40e-Make-the-DCB-firmware-checks-for-X710-XL710-onl.patch"
SRC_URI += "file://0743-i40e-set-shared-bit-for-multicast-filters.patch"
SRC_URI += "file://0744-i40e-add-VEB-stat-control-and-remove-L2-cloud-filter.patch"
SRC_URI += "file://0745-i40e-use-new-add_veb-calling-with-VEB-stats-control.patch"
SRC_URI += "file://0746-i40e-Refactor-force_wb-and-WB_ON_ITR-functionality-c.patch"
SRC_URI += "file://0747-i40evf-Change-vf-driver-string-to-reflect-all-produc.patch"
SRC_URI += "file://0748-i40e-i40evf-don-t-lose-interrupts.patch"
SRC_URI += "file://0749-i40e-i40evf-try-again-after-failure.patch"
SRC_URI += "file://0750-i40e-dump-descriptor-indexes-in-hex.patch"
SRC_URI += "file://0751-i40e-i40evf-use-__GFP_NOWARN.patch"
SRC_URI += "file://0752-i40e-i40evf-use-pages-correctly-in-Rx.patch"
SRC_URI += "file://0753-i40e-i40evf-use-logical-operators-not-bitwise.patch"
SRC_URI += "file://0754-i40e-properly-show-packet-split-status-in-debugfs.patch"
SRC_URI += "file://0755-i40e-i40evf-Bump-version.patch"
SRC_URI += "file://0756-ixgbe-use-u32-instead-of-__u32-in-model-header.patch"
SRC_URI += "file://0757-ixgbe-fix-dates-on-header-of-ixgbe_model.h.patch"
SRC_URI += "file://0758-i40e-get-rid-of-magic-number.patch"
SRC_URI += "file://0759-i40e-drop-unused-debugfs-file-dump.patch"
SRC_URI += "file://0760-i40evf-support-packet-split-receive.patch"
SRC_URI += "file://0761-i40e-trivial-cleanup-use-of-pf-hw.patch"
SRC_URI += "file://0762-i40e-Add-a-SW-workaround-for-lost-interrupts.patch"
SRC_URI += "file://0763-i40e-Fix-PROMISC-mode-for-Multi-function-per-port-MF.patch"
SRC_URI += "file://0764-i40e-Removal-of-code-which-relies-on-BASE-VEB-SEID.patch"
SRC_URI += "file://0765-i40e-i40evf-avoid-atomics.patch"
SRC_URI += "file://0766-i40e-Do-not-disable-queues-in-the-Legacy-MSI-Interru.patch"
SRC_URI += "file://0767-i40e-expand-comment.patch"
SRC_URI += "file://0768-i40e-better-error-reporting-for-nvmupdate.patch"
SRC_URI += "file://0769-i40evf-set-adapter-state-on-reset-failure.patch"
SRC_URI += "file://0770-i40e-clean-event-descriptor-before-use.patch"
SRC_URI += "file://0771-i40e-When-in-promisc-mode-apply-promisc-mode-to-Tx-T.patch"
SRC_URI += "file://0772-i40e-i40evf-Bump-i40e-to-1.4.15-and-i40evf-to-1.4.11.patch"
SRC_URI += "file://0773-i40e-i40evf-Drop-outer-checksum-offload-that-was-not.patch"
SRC_URI += "file://0774-i40e-i40evf-Use-u64-values-instead-of-casting-them-i.patch"
SRC_URI += "file://0775-i40e-i40evf-Factor-out-L4-header-and-checksum-from-L.patch"
SRC_URI += "file://0776-i40e-i40evf-Consolidate-all-header-changes-into-TSO-.patch"
SRC_URI += "file://0777-i40e-i40evf-Replace-header-pointers-with-unions-of-p.patch"
SRC_URI += "file://0778-i40e-i40evf-Add-support-for-IPv4-encapsulated-in-IPv.patch"
SRC_URI += "file://0779-i40e-i40evf-Handle-IPv6-extension-headers-in-checksu.patch"
SRC_URI += "file://0780-i40e-i40evf-Do-not-write-to-descriptor-unless-we-com.patch"
SRC_URI += "file://0781-i40e-i40evf-Add-exception-handling-for-Tx-checksum.patch"
SRC_URI += "file://0782-i40e-i40evf-Clean-up-Rx-packet-checksum-handling.patch"
SRC_URI += "file://0783-i40e-i40evf-Enable-support-for-SKB_GSO_UDP_TUNNEL_CS.patch"
SRC_URI += "file://0784-i40e-Fix-ATR-in-relation-to-tunnels.patch"
SRC_URI += "file://0785-i40e-Do-not-drop-support-for-IPv6-VXLAN-or-GENEVE-tu.patch"
SRC_URI += "file://0786-i40e-Update-feature-flags-to-reflect-newly-enabled-f.patch"
SRC_URI += "file://0787-i40evf-Update-feature-flags-to-reflect-newly-enabled.patch"
SRC_URI += "file://0788-i40e-Add-support-for-ATR-w-IPv6-extension-headers.patch"
SRC_URI += "file://0789-i40e-i40evf-Break-up-xmit_descriptor_count-from-mayb.patch"
SRC_URI += "file://0790-i40e-i40evf-Rewrite-logic-for-8-descriptor-per-packe.patch"
SRC_URI += "file://0791-i40e-i40evf-Move-Tx-checksum-closer-to-TSO.patch"
SRC_URI += "file://0792-i40e-Add-functions-to-blink-led-on-10GBaseT-PHY.patch"
SRC_URI += "file://0793-i40e-Fix-led-blink-capability-for-10GBaseT-PHY.patch"
SRC_URI += "file://0794-i40e-Increase-timeout-when-checking-GLGEN_RSTAT_DEVS.patch"
SRC_URI += "file://0795-i40e-Do-not-wait-for-Rx-queue-disable-in-DCB-reconfi.patch"
SRC_URI += "file://0796-i40e-Fix-for-unexpected-messaging.patch"
SRC_URI += "file://0797-i40e-Expose-some-registers-to-program-parser-FD-and-.patch"
SRC_URI += "file://0798-i40e-add-check-for-null-VSI.patch"
SRC_URI += "file://0799-i40e-add-adminq-commands-for-Rx-CTL-registers.patch"
SRC_URI += "file://0800-i40e-implement-and-use-Rx-CTL-helper-functions.patch"
SRC_URI += "file://0801-i40e-Use-the-new-rx-ctl-register-helpers.-Don-t-use-.patch"
SRC_URI += "file://0802-i40e-suspend-scheduling-during-driver-unload.patch"
SRC_URI += "file://0803-i40e-let-go-of-the-past.patch"
SRC_URI += "file://0804-i40e-i40evf-Bump-i40e-to-1.4.25-and-i40evf-to-1.4.15.patch"
SRC_URI += "file://0805-UBUNTU-SAUCE-cred-Add-clone_cred-interface.patch"
SRC_URI += "file://0806-UBUNTU-SAUCE-overlayfs-Use-mounter-s-credentials-ins.patch"
SRC_URI += "file://0807-UBUNTU-SAUCE-overlayfs-Skip-permission-checking-for-.patch"
SRC_URI += "file://0808-UBUNTU-SAUCE-overlayfs-Be-more-careful-about-copying.patch"
SRC_URI += "file://0809-UBUNTU-SAUCE-overlayfs-Propogate-nosuid-from-lower-a.patch"
SRC_URI += "file://0810-UBUNTU-SAUCE-arm-mm-avoid-calling-apply_to_page_rang.patch"
SRC_URI += "file://0811-UBUNTU-SAUCE-kernfs-Always-set-super-block-owner-to-.patch"
SRC_URI += "file://0812-hrtimer-Add-support-for-CLOCK_MONOTONIC_RAW.patch"
SRC_URI += "file://0813-hrtimer-Catch-illegal-clockids.patch"
SRC_URI += "file://0814-KVM-arm-arm64-timer-Switch-to-CLOCK_MONOTONIC_RAW.patch"
SRC_URI += "file://0815-drm-i915-remove-an-extra-level-of-indirection-in-PCI.patch"
SRC_URI += "file://0816-drm-i915-kbl-Add-Kabylake-PCI-ID.patch"
SRC_URI += "file://0817-drm-i915-kbl-Add-Kabylake-GT4-PCI-ID.patch"
SRC_URI += "file://0818-mm-Export-nr_swap_pages.patch"
SRC_URI += "file://0819-async-export-current_is_async.patch"
SRC_URI += "file://0820-drm-fix-potential-dangling-else-problems-in-for_each.patch"
SRC_URI += "file://0821-dp-mst-add-SDP-stream-support.patch"
SRC_URI += "file://0822-drm-Implement-drm_modeset_lock_all_ctx.patch"
SRC_URI += "file://0823-drm-Add-prefix-parameter-to-drm_rect_debug_print.patch"
SRC_URI += "file://0824-drm-i915-Set-connector_state-connector-using-the-hel.patch"
SRC_URI += "file://0825-drm-atomic-add-connector-mask-to-drm_crtc_state.patch"
SRC_URI += "file://0826-drm-i915-Report-context-GTT-size.patch"
SRC_URI += "file://0827-drm-i915-Add-get_eld-audio-component.patch"
SRC_URI += "file://0828-UBUNTU-SAUCE-Backport-I915_PARAM_HAS_EXEC_SOFTPIN-an.patch"
SRC_URI += "file://0829-UBUNTU-SAUCE-sound-hda-Load-i915_bpo-from-the-hda-dr.patch"
SRC_URI += "file://0830-drm-i915-bxt-update-list-of-PCIIDs.patch"
SRC_URI += "file://0831-drm-i915-skl-Add-missing-SKL-ids.patch"
SRC_URI += "file://0832-UBUNTU-SAUCE-uapi-drm-i915-Backport-I915_EXEC_BSD_MA.patch"
SRC_URI += "file://0833-drm-atomic-Do-not-unset-crtc-when-an-encoder-is-stol.patch"
SRC_URI += "file://0834-drm-i915-Update-connector_mask-during-readout-v2.patch"
SRC_URI += "file://0835-drm-atomic-Add-encoder_mask-to-crtc_state-v3.patch"
SRC_URI += "file://0836-UBUNTU-SAUCE-drm-core-Add-drm_encoder_index.patch"
SRC_URI += "file://0837-EDAC-sb_edac-Set-fixed-DIMM-width-on-Xeon-Knights-La.patch"
SRC_URI += "file://0838-cxl-Fix-PSL-timebase-synchronization-detection.patch"
SRC_URI += "file://0839-KVM-x86-fix-conversion-of-addresses-to-linear-in-32-.patch"
SRC_URI += "file://0840-x86-entry-compat-Add-missing-CLAC-to-entry_INT80_32.patch"
SRC_URI += "file://0841-x86-mpx-Fix-off-by-one-comparison-with-nr_registers.patch"
SRC_URI += "file://0842-UBUNTU-SAUCE-tools-lib-bpf-add-generated-headers-to-.patch"
SRC_URI += "file://0843-UBUNTU-SAUCE-proc-Always-set-super-block-owner-to-in.patch"
SRC_URI += "file://0844-UBUNTU-SAUCE-apparmor-fix-sleep-from-invalid-context.patch"
SRC_URI += "file://0845-UBUNTU-SAUCE-fix-up-kern_mount-fail-path-should-not-.patch"
SRC_URI += "file://0846-UBUNTU-SAUCE-apparmor-Fix-oops-do-to-invalid-null-pt.patch"
SRC_URI += "file://0847-UBUNTU-SAUCE-apparmor-Disallow-update-of-cred-when-t.patch"
SRC_URI += "file://0848-UBUNTU-SAUCE-apparmor-rework-retrieval-of-the-curren.patch"
SRC_URI += "file://0849-UBUNTU-SAUCE-apparmor-Fix-insert-race-between-label_.patch"
SRC_URI += "file://0850-UBUNTU-SAUCE-apparmor-Fix-ensure-aa_get_newest-will-.patch"
SRC_URI += "file://0851-UBUNTU-SAUCE-apparmor-debug-POISON-label-and-replace.patch"
SRC_URI += "file://0852-UBUNTU-SAUCE-apparmor-add-underscores-to-indicate-aa.patch"
SRC_URI += "file://0853-UBUNTU-SAUCE-apparmor-Fix-label-merge-handling-of-ma.patch"
SRC_URI += "file://0854-UBUNTU-SAUCE-apparmor-Fix-refcount-race-between-loca.patch"
SRC_URI += "file://0855-UBUNTU-SAUCE-apparmor-Fix-refcount-leak-in-aa_label_.patch"
SRC_URI += "file://0856-UBUNTU-SAUCE-apparmor-Fix-ensure-new-labels-resultin.patch"
SRC_URI += "file://0857-UBUNTU-SAUCE-apparmor-Fix-label_vec_merge-insertion.patch"
SRC_URI += "file://0858-UBUNTU-SAUCE-apparmor-Fix-deadlock-in-aa_put_label-c.patch"
SRC_URI += "file://0859-UBUNTU-SAUCE-apparmor-Fix-add-required-locking-of-__.patch"
SRC_URI += "file://0860-UBUNTU-SAUCE-apparmor-Fix-convert-replacedby-update-.patch"
SRC_URI += "file://0861-UBUNTU-SAUCE-apparmor-Fix-update-replacedby-allocati.patch"
SRC_URI += "file://0862-UBUNTU-SAUCE-apparmor-ensure-that-repacedby-sharing-.patch"
SRC_URI += "file://0863-UBUNTU-SAUCE-apparmor-Fix-refcount-bug-in-pivotroot-.patch"
SRC_URI += "file://0864-UBUNTU-SAUCE-apparmor-Fix-now-that-insert-can-force-.patch"
SRC_URI += "file://0865-UBUNTU-SAUCE-apparmor-Fix-refcount-bug-when-insertin.patch"
SRC_URI += "file://0866-UBUNTU-SAUCE-apparmor-Fix-break-circular-refcount-fo.patch"
SRC_URI += "file://0867-UBUNTU-SAUCE-apparmor-Don-t-remove-label-on-rcu-call.patch"
SRC_URI += "file://0868-UBUNTU-SAUCE-apparmor-Fix-query-label-file-permissio.patch"
SRC_URI += "file://0869-UBUNTU-SAUCE-apparmor-fix-ref-count-leak-when-profil.patch"
SRC_URI += "file://0870-UBUNTU-SAUCE-fixup-cleanup-return-handling-of-labels.patch"
SRC_URI += "file://0871-UBUNTU-SAUCE-apparmor-fix-log-of-apparmor-audit-mess.patch"
SRC_URI += "file://0872-UBUNTU-SAUCE-fix-replacedby-forwarding-is-not-being-.patch"
SRC_URI += "file://0873-UBUNTU-SAUCE-fixup-make-__share_replacedby-private-t.patch"
SRC_URI += "file://0874-UBUNTU-SAUCE-fixup-20-23-locking-issue-around-in-__l.patch"
SRC_URI += "file://0875-UBUNTU-SAUCE-fixup-get-rid-of-unused-var-build-warni.patch"
SRC_URI += "file://0876-UBUNTU-SAUCE-fixup-cast-poison-values-to-remove-warn.patch"
SRC_URI += "file://0877-UBUNTU-SAUCE-apparmor-fix-refcount-race-when-finding.patch"
SRC_URI += "file://0878-UBUNTU-SAUCE-fixup-warning-about-aa_label_vec_find_o.patch"
SRC_URI += "file://0879-UBUNTU-SAUCE-fix-audit-no_new_privs-case-for-exec-fa.patch"
SRC_URI += "file://0880-UBUNTU-SAUCE-Fixup-__label_update-still-doesn-t-hand.patch"
SRC_URI += "file://0881-UBUNTU-SAUCE-Move-replacedby-allocation-into-label_a.patch"
SRC_URI += "file://0882-mmc-sdhci-64-bit-DMA-actually-has-4-byte-alignment.patch"
SRC_URI += "file://0883-mmc-sdhci-Fix-DMA-descriptor-with-zero-data-length.patch"
SRC_URI += "file://0884-UBUNTU-SAUCE-noup-cgroup-fix-and-restructure-error-h.patch"
SRC_URI += "file://0885-UBUNTU-SAUCE-noup-locking-qspinlock-Move-__ARCH_SPIN.patch"
SRC_URI += "file://0886-security-let-security-modules-use-PTRACE_MODE_-with-.patch"
SRC_URI += "file://0887-target-transport-add-flag-to-indicate-CPU-Affinity-i.patch"
SRC_URI += "file://0888-qla2xxx-Fix-warning-reported-by-static-checker.patch"
SRC_URI += "file://0889-qla2xxx-Fix-TMR-ABORT-interaction-issue-between-qla2.patch"
SRC_URI += "file://0890-qla2xxx-Fix-stale-pointer-access.patch"
SRC_URI += "file://0891-qla2xxx-Use-ATIO-type-to-send-correct-tmr-response.patch"
SRC_URI += "file://0892-qla2xxx-use-TARGET_SCF_USE_CPUID-flag-to-indiate-CPU.patch"
SRC_URI += "file://0893-net-mlx4_en-Choose-time-stamping-shift-value-accordi.patch"
SRC_URI += "file://0894-af_iucv-Validate-socket-address-length-in-iucv_sock_.patch"
SRC_URI += "file://0895-gro-Make-GRO-aware-of-lightweight-tunnels.patch"
SRC_URI += "file://0896-net-dp83640-Fix-tx-timestamp-overflow-handling.patch"
SRC_URI += "file://0897-tunnels-Allow-IPv6-UDP-checksums-to-be-correctly-con.patch"
SRC_URI += "file://0898-lwt-fix-rx-checksum-setting-for-lwt-devices-tunnelin.patch"
SRC_URI += "file://0899-tcp-fix-NULL-deref-in-tcp_v4_send_ack.patch"
SRC_URI += "file://0900-af_unix-fix-struct-pid-memory-leak.patch"
SRC_URI += "file://0901-pptp-fix-illegal-memory-access-caused-by-multiple-bi.patch"
SRC_URI += "file://0902-sctp-allow-setting-SCTP_SACK_IMMEDIATELY-by-the-appl.patch"
SRC_URI += "file://0903-net-dsa-fix-mv88e6xxx-switches.patch"
SRC_URI += "file://0904-tipc-fix-connection-abort-during-subscription-cancel.patch"
SRC_URI += "file://0905-inet-frag-Always-orphan-skbs-inside-ip_defrag.patch"
SRC_URI += "file://0906-switchdev-Require-RTNL-mutex-to-be-held-when-sending.patch"
SRC_URI += "file://0907-tcp-beware-of-alignments-in-tcp_get_info.patch"
SRC_URI += "file://0908-ipv6-enforce-flowi6_oif-usage-in-ip6_dst_lookup_tail.patch"
SRC_URI += "file://0909-ipv6-udp-use-sticky-pktinfo-egress-ifindex-on-connec.patch"
SRC_URI += "file://0910-ipv6-addrconf-Fix-recursive-spin-lock-call.patch"
SRC_URI += "file://0911-ipv6-fix-a-lockdep-splat.patch"
SRC_URI += "file://0912-unix-correctly-track-in-flight-fds-in-sending-proces.patch"
SRC_URI += "file://0913-tcp-do-not-drop-syn_recv-on-all-icmp-reports.patch"
SRC_URI += "file://0914-net-Add-sysctl_max_skb_frags.patch"
SRC_URI += "file://0915-tg3-Fix-for-tg3-transmit-queue-0-timed-out-when-too-.patch"
SRC_URI += "file://0916-enic-increment-devcmd2-result-ring-in-case-of-timeou.patch"
SRC_URI += "file://0917-sctp-translate-network-order-to-host-order-when-user.patch"
SRC_URI += "file://0918-net-Copy-inner-L3-and-L4-headers-as-unaligned-on-GRE.patch"
SRC_URI += "file://0919-flow_dissector-Fix-unaligned-access-in-__skb_flow_di.patch"
SRC_URI += "file://0920-bpf-fix-branch-offset-adjustment-on-backjumps-after-.patch"
SRC_URI += "file://0921-bonding-Fix-ARP-monitor-validation.patch"
SRC_URI += "file://0922-ipv4-fix-memory-leaks-in-ip_cmsg_send-callers.patch"
SRC_URI += "file://0923-af_unix-Don-t-set-err-in-unix_stream_read_generic-un.patch"
SRC_URI += "file://0924-af_unix-Guard-against-other-sk-in-unix_dgram_sendmsg.patch"
SRC_URI += "file://0925-tipc-fix-premature-addition-of-node-to-lookup-table.patch"
SRC_URI += "file://0926-tcp-md5-release-request-socket-instead-of-listener.patch"
SRC_URI += "file://0927-qmi_wwan-add-4G-LTE-usb-modem-U901.patch"
SRC_URI += "file://0928-net-mlx4_en-Count-HW-buffer-overrun-only-once.patch"
SRC_URI += "file://0929-net-mlx4_en-Avoid-changing-dev-features-directly-in-.patch"
SRC_URI += "file://0930-l2tp-Fix-error-creating-L2TP-tunnels.patch"
SRC_URI += "file://0931-pppoe-fix-reference-counting-in-PPPoE-proxy.patch"
SRC_URI += "file://0932-net_sched-fix-reclassification-needs-to-consider-eth.patch"
SRC_URI += "file://0933-route-check-and-remove-route-cache-when-we-get-route.patch"
SRC_URI += "file://0934-tcp-dccp-fix-another-race-at-listener-dismantle.patch"
SRC_URI += "file://0935-IFF_NO_QUEUE-Fix-for-drivers-not-calling-ether_setup.patch"
SRC_URI += "file://0936-rtnl-RTM_GETNETCONF-fix-wrong-return-value.patch"
SRC_URI += "file://0937-tipc-unlock-in-error-path.patch"
SRC_URI += "file://0938-unix_diag-fix-incorrect-sign-extension-in-unix_looku.patch"
SRC_URI += "file://0939-sctp-Fix-port-hash-table-size-computation.patch"
SRC_URI += "file://0940-ext4-fix-bh-b_state-corruption.patch"
SRC_URI += "file://0941-ARM-debug-ll-fix-BCM63xx-entry-for-multiplatform.patch"
SRC_URI += "file://0942-arm64-errata-Add-mpc-relative-literal-loads-to-build.patch"
SRC_URI += "file://0943-devm_memremap-Fix-error-value-when-memremap-failed.patch"
SRC_URI += "file://0944-drm-gma500-Use-correct-unref-in-the-gem-bo-create-fu.patch"
SRC_URI += "file://0945-ARM-8457-1-psci-smp-is-built-only-for-SMP.patch"
SRC_URI += "file://0946-lib-ucs2_string-Add-ucs2-utf8-helper-functions.patch"
SRC_URI += "file://0947-efi-Use-ucs2_as_utf8-in-efivarfs-instead-of-open-cod.patch"
SRC_URI += "file://0948-efi-Do-variable-name-validation-tests-in-utf8.patch"
SRC_URI += "file://0949-efi-Make-our-variable-validation-list-include-the-gu.patch"
SRC_URI += "file://0950-efi-Make-efivarfs-entries-immutable-by-default.patch"
SRC_URI += "file://0951-efi-Add-pstore-variables-to-the-deletion-whitelist.patch"
SRC_URI += "file://0952-lib-ucs2_string-Correct-ucs2-utf8-conversion.patch"
SRC_URI += "file://0953-bcache-fix-a-livelock-when-we-cause-a-huge-number-of.patch"
SRC_URI += "file://0954-bcache-Add-a-cond_resched-call-to-gc.patch"
SRC_URI += "file://0955-bcache-clear-BCACHE_DEV_UNLINK_DONE-flag-when-attach.patch"
SRC_URI += "file://0956-bcache-fix-a-leak-in-bch_cached_dev_run.patch"
SRC_URI += "file://0957-bcache-unregister-reboot-notifier-if-bcache-fails-to.patch"
SRC_URI += "file://0958-bcache-allows-use-of-register-in-udev-to-avoid-devic.patch"
SRC_URI += "file://0959-bcache-Change-refill_dirty-to-always-scan-entire-dis.patch"
SRC_URI += "file://0960-dm-thin-fix-race-condition-when-destroying-thin-pool.patch"
SRC_URI += "file://0961-can-ems_usb-Fix-possible-tx-overflow.patch"
SRC_URI += "file://0962-usb-dwc3-Fix-assignment-of-EP-transfer-resources.patch"
SRC_URI += "file://0963-USB-cp210x-add-IDs-for-GE-B650V3-and-B850V3-boards.patch"
SRC_URI += "file://0964-USB-option-add-support-for-SIM7100E.patch"
SRC_URI += "file://0965-USB-option-add-4G-LTE-usb-modem-U901.patch"
SRC_URI += "file://0966-drivers-android-correct-the-size-of-struct-binder_ui.patch"
SRC_URI += "file://0967-spi-omap2-mcspi-Prevent-duplicate-gpio_request.patch"
SRC_URI += "file://0968-iw_cxgb3-Fix-incorrectly-returning-error-on-success.patch"
SRC_URI += "file://0969-drm-i915-shut-up-gen8-SDE-irq-dmesg-noise.patch"
SRC_URI += "file://0970-ocfs2-unlock-inode-if-deleting-inode-from-orphan-fai.patch"
SRC_URI += "file://0971-mm-thp-fix-SMP-race-condition-between-THP-page-fault.patch"
SRC_URI += "file://0972-mm-numa-quickly-fail-allocations-for-NUMA-balancing-.patch"
SRC_URI += "file://0973-genirq-Validate-action-before-dereferencing-it-in-ha.patch"
SRC_URI += "file://0974-clocksource-drivers-vt8500-Increase-the-minimum-delt.patch"
SRC_URI += "file://0975-Btrfs-add-missing-brelse-when-superblock-checksum-fa.patch"
SRC_URI += "file://0976-Btrfs-igrab-inode-in-writepage.patch"
SRC_URI += "file://0977-btrfs-statfs-report-zero-available-if-metadata-are-e.patch"
SRC_URI += "file://0978-Btrfs-send-don-t-BUG_ON-when-an-empty-symlink-is-fou.patch"
SRC_URI += "file://0979-Btrfs-fix-number-of-transaction-units-required-to-cr.patch"
SRC_URI += "file://0980-Btrfs-fix-transaction-handle-leak-on-failure-to-crea.patch"
SRC_URI += "file://0981-Btrfs-Initialize-btrfs_root-highest_objectid-when-lo.patch"
SRC_URI += "file://0982-btrfs-initialize-the-seq-counter-in-struct-btrfs_dev.patch"
SRC_URI += "file://0983-uml-flush-stdout-before-forking.patch"
SRC_URI += "file://0984-uml-fix-hostfs-mknod.patch"
SRC_URI += "file://0985-um-link-with-lpthread.patch"
SRC_URI += "file://0986-locks-fix-unlock-when-fcntl_setlk-races-with-a-close.patch"
SRC_URI += "file://0987-rtlwifi-rtl_pci-Fix-kernel-panic.patch"
SRC_URI += "file://0988-rtlwifi-rtl8192cu-Add-missing-parameter-setup.patch"
SRC_URI += "file://0989-rtlwifi-rtl8192ce-Fix-handling-of-module-parameters.patch"
SRC_URI += "file://0990-rtlwifi-rtl8192de-Fix-incorrect-module-parameter-des.patch"
SRC_URI += "file://0991-rtlwifi-rtl8723ae-Fix-initialization-of-module-param.patch"
SRC_URI += "file://0992-rtlwifi-rtl8192se-Fix-module-parameter-initializatio.patch"
SRC_URI += "file://0993-rtlwifi-rtl8188ee-Fix-module-parameter-initializatio.patch"
SRC_URI += "file://0994-rtlwifi-rtl8723be-Fix-module-parameter-initializatio.patch"
SRC_URI += "file://0995-mei-fix-fasync-return-value-on-error.patch"
SRC_URI += "file://0996-mei-validate-request-value-in-client-notify-request-.patch"
SRC_URI += "file://0997-namei-d_inode-of-a-pinned-dentry-is-stable-only-for-.patch"
SRC_URI += "file://0998-rc-sunxi-cir-Initialize-the-spinlock-properly.patch"
SRC_URI += "file://0999-media-dvb-core-Don-t-force-CAN_INVERSION_AUTO-in-one.patch"
SRC_URI += "file://1000-si2157-return-EINVAL-if-firmware-blob-is-too-big.patch"
SRC_URI += "file://1001-gspca-ov534-topro-prevent-a-division-by-0.patch"
SRC_URI += "file://1002-vb2-fix-a-regression-in-poll-behavior-for-output-str.patch"
SRC_URI += "file://1003-tda1004x-only-update-the-frontend-properties-if-lock.patch"
SRC_URI += "file://1004-dm-space-map-metadata-remove-unused-variable-in-brb_.patch"
SRC_URI += "file://1005-dm-snapshot-fix-hung-bios-when-copy-error-occurs.patch"
SRC_URI += "file://1006-dm-fix-dm_rq_target_io-leak-on-faults-with-.request_.patch"
SRC_URI += "file://1007-coresight-checking-for-NULL-string-in-coresight_name.patch"
SRC_URI += "file://1008-irqchip-omap-intc-Add-support-for-spurious-irq-handl.patch"
SRC_URI += "file://1009-irqchip-mxs-Add-missing-set_handle_irq.patch"
SRC_URI += "file://1010-irqchip-atmel-aic-Fix-wrong-bit-operation-for-IRQ-pr.patch"
SRC_URI += "file://1011-irqchip-gic-v3-its-Fix-double-ICC_EOIR-write-for-LPI.patch"
SRC_URI += "file://1012-posix-clock-Fix-return-code-on-the-poll-method-s-err.patch"
SRC_URI += "file://1013-clockevents-tcb_clksrc-Prevent-disabling-an-already-.patch"
SRC_URI += "file://1014-mmc-usdhi6rol0-handle-NULL-data-in-timeout.patch"
SRC_URI += "file://1015-mmc-sdhci-pci-Do-not-default-to-33-Ohm-driver-streng.patch"
SRC_URI += "file://1016-mmc-sdio-Fix-invalid-vdd-in-voltage-switch-power-cyc.patch"
SRC_URI += "file://1017-mmc-mmc-Fix-incorrect-use-of-driver-strength-switchi.patch"
SRC_URI += "file://1018-mmc-sdhci-Fix-sdhci_runtime_pm_bus_on-off.patch"
SRC_URI += "file://1019-mmc-core-Enable-tuning-according-to-the-actual-timin.patch"
SRC_URI += "file://1020-mmc-mmci-fix-an-ages-old-detection-error.patch"
SRC_URI += "file://1021-mmc-sdhci-acpi-Fix-card-detect-race-for-Intel-BXT-AP.patch"
SRC_URI += "file://1022-mmc-pxamci-fix-again-read-only-gpio-detection-polari.patch"
SRC_URI += "file://1023-mmc-sdhci-pci-Fix-card-detect-race-for-Intel-BXT-APL.patch"
SRC_URI += "file://1024-mmc-sdhci-Allow-override-of-mmc-host-operations.patch"
SRC_URI += "file://1025-mmc-sdhci-Allow-override-of-get_cd-called-from-sdhci.patch"
SRC_URI += "file://1026-Bluetooth-Use-continuous-scanning-when-creating-LE-c.patch"
SRC_URI += "file://1027-Bluetooth-Add-support-of-Toshiba-Broadcom-based-devi.patch"
SRC_URI += "file://1028-Bluetooth-Fix-incorrect-removing-of-IRKs.patch"
SRC_URI += "file://1029-Bluetooth-6lowpan-Fix-kernel-NULL-pointer-dereferenc.patch"
SRC_URI += "file://1030-Bluetooth-6lowpan-Fix-handling-of-uncompressed-IPv6-.patch"
SRC_URI += "file://1031-time-Avoid-signed-overflow-in-timekeeping_get_ns.patch"
SRC_URI += "file://1032-cputime-Prevent-32bit-overflow-in-time-val-spec-_to_.patch"
SRC_URI += "file://1033-Revert-MIPS-Fix-PAGE_MASK-definition.patch"
SRC_URI += "file://1034-MIPS-Loongson-3-Fix-SMP_ASK_C0COUNT-IPI-handler.patch"
SRC_URI += "file://1035-MIPS-hpet-Choose-a-safe-value-for-the-ETIME-check.patch"
SRC_URI += "file://1036-MIPS-Fix-some-missing-CONFIG_CPU_MIPSR6-ifdefs.patch"
SRC_URI += "file://1037-MIPS-Fix-buffer-overflow-in-syscall_get_arguments.patch"
SRC_URI += "file://1038-EDAC-Robustify-workqueues-destruction.patch"
SRC_URI += "file://1039-EDAC-mc_sysfs-Fix-freeing-bus-name.patch"
SRC_URI += "file://1040-sparc64-fix-incorrect-sign-extension-in-sys_sparc64_.patch"
SRC_URI += "file://1041-clk-exynos-use-irqsave-version-of-spin_lock-to-avoid.patch"
SRC_URI += "file://1042-regulator-axp20x-Fix-GPIO-LDO-enable-value-for-AXP22.patch"
SRC_URI += "file://1043-regulator-mt6311-MT6311_REGULATOR-needs-to-select-RE.patch"
SRC_URI += "file://1044-virtio_balloon-fix-race-by-fill-and-leak.patch"
SRC_URI += "file://1045-virtio_balloon-fix-race-between-migration-and-balloo.patch"
SRC_URI += "file://1046-virtio_pci-fix-use-after-free-on-release.patch"
SRC_URI += "file://1047-drm-vmwgfx-Fix-an-incorrect-lock-check.patch"
SRC_URI += "file://1048-drm-vmwgfx-Fix-a-width-pitch-mismatch-on-framebuffer.patch"
SRC_URI += "file://1049-drm-vmwgfx-respect-nomodeset.patch"
SRC_URI += "file://1050-drm-amdgpu-Fix-off-by-one-errors-in-amdgpu_vm_bo_map.patch"
SRC_URI += "file://1051-drm-amdgpu-call-hpd_irq_event-on-resume.patch"
SRC_URI += "file://1052-drm-amdgpu-fix-lost-sync_to-if-scheduler-is-enabled.patch"
SRC_URI += "file://1053-drm-amdgpu-fix-tonga-smu-resume.patch"
SRC_URI += "file://1054-drm-amdgpu-fix-amdgpu_bo_pin_restricted-VRAM-placing.patch"
SRC_URI += "file://1055-drm-amdgpu-no-need-to-load-MC-firmware-on-fiji.patch"
SRC_URI += "file://1056-drm-amdgpu-move-gmc7-support-out-of-CIK-dependency.patch"
SRC_URI += "file://1057-drm-amdgpu-iceland-use-CI-based-MC-IP.patch"
SRC_URI += "file://1058-drm-amdgpu-The-VI-specific-EXE-bit-should-only-apply.patch"
SRC_URI += "file://1059-drm-amdgpu-pull-topaz-gmc-bits-into-gmc_v7.patch"
SRC_URI += "file://1060-drm-amdgpu-drop-topaz-support-from-gmc8-module.patch"
SRC_URI += "file://1061-drm-amdgpu-don-t-load-MEC2-on-topaz.patch"
SRC_URI += "file://1062-drm-amdgpu-remove-exp-hardware-support-from-iceland.patch"
SRC_URI += "file://1063-drm-amdgpu-fix-s4-resume.patch"
SRC_URI += "file://1064-drm-amdgpu-remove-unnecessary-forward-declaration.patch"
SRC_URI += "file://1065-drm-amdgpu-hold-reference-to-fences-in-amdgpu_sa_bo_.patch"
SRC_URI += "file://1066-drm-amdgpu-fix-issue-with-overlapping-userptrs.patch"
SRC_URI += "file://1067-drm-amdgpu-use-post-decrement-in-error-handling.patch"
SRC_URI += "file://1068-drm-amdgpu-Don-t-hang-in-amdgpu_flip_work_func-on-di.patch"
SRC_URI += "file://1069-drm-amdgpu-pm-adjust-display-configuration-after-pow.patch"
SRC_URI += "file://1070-drm-nouveau-kms-take-mode_config-mutex-in-connector-.patch"
SRC_URI += "file://1071-drm-nouveau-display-Enable-vblank-irqs-after-display.patch"
SRC_URI += "file://1072-drm-nouveau-disp-dp-ensure-sink-is-powered-up-before.patch"
SRC_URI += "file://1073-drm-nouveau-platform-Fix-deferred-probe.patch"
SRC_URI += "file://1074-drm-dp-mst-process-broadcast-messages-correctly.patch"
SRC_URI += "file://1075-drm-dp-mst-always-send-reply-for-UP-request.patch"
SRC_URI += "file://1076-drm-dp-mst-fix-in-MSTB-RAD-initialization.patch"
SRC_URI += "file://1077-drm-dp-mst-fix-in-RAD-element-access.patch"
SRC_URI += "file://1078-drm-Add-drm_fixp_from_fraction-and-drm_fixp2int_ceil.patch"
SRC_URI += "file://1079-drm-dp-mst-Calculate-MST-PBN-with-31.32-fixed-point.patch"
SRC_URI += "file://1080-drm-dp-mst-move-GUID-storage-from-mgr-port-to-only-m.patch"
SRC_URI += "file://1081-drm-dp-mst-Reverse-order-of-MST-enable-and-clearing-.patch"
SRC_URI += "file://1082-drm-dp-mst-deallocate-payload-on-port-destruction.patch"
SRC_URI += "file://1083-drm-radeon-Fix-off-by-one-errors-in-radeon_vm_bo_set.patch"
SRC_URI += "file://1084-drm-radeon-call-hpd_irq_event-on-resume.patch"
SRC_URI += "file://1085-drm-radeon-Fix-slow-audio-over-DP-on-DCE8.patch"
SRC_URI += "file://1086-drm-radeon-clean-up-fujitsu-quirks.patch"
SRC_URI += "file://1087-drm-radeon-properly-byte-swap-vce-firmware-setup.patch"
SRC_URI += "file://1088-drm-radeon-cleaned-up-VCO-output-settings-for-DP-aud.patch"
SRC_URI += "file://1089-drm-radeon-Add-a-common-function-for-DFS-handling.patch"
SRC_URI += "file://1090-drm-radeon-fix-DP-audio-support-for-APU-with-DCE4.1-.patch"
SRC_URI += "file://1091-drm-add-helper-to-check-for-wc-memory-support.patch"
SRC_URI += "file://1092-drm-radeon-mask-out-WC-from-BO-on-unsupported-arches.patch"
SRC_URI += "file://1093-drm-radeon-hold-reference-to-fences-in-radeon_sa_bo_.patch"
SRC_URI += "file://1094-drm-fix-missing-reference-counting-decrease.patch"
SRC_URI += "file://1095-drm-i915-Restore-inhibiting-the-load-of-the-default-.patch"
SRC_URI += "file://1096-drm-i915-intel_hpd_init-Fix-suspend-resume-reprobing.patch"
SRC_URI += "file://1097-drm-i915-Init-power-domains-early-in-driver-load.patch"
SRC_URI += "file://1098-drm-i915-Make-sure-DC-writes-are-coherent-on-flush.patch"
SRC_URI += "file://1099-drm-i915-dp-fall-back-to-18-bpp-when-sink-capability.patch"
SRC_URI += "file://1100-drm-i915-Don-t-reject-primary-plane-windowing-with-c.patch"
SRC_URI += "file://1101-drm-i915-skl-Don-t-skip-mst-encoders-in-skl_ddi_pll_.patch"
SRC_URI += "file://1102-drm-i915-dsi-defend-gpio-table-against-out-of-bounds.patch"
SRC_URI += "file://1103-drm-i915-dsi-don-t-pass-arbitrary-data-to-sideband.patch"
SRC_URI += "file://1104-drm-i915-fix-error-path-in-intel_setup_gmbus.patch"
SRC_URI += "file://1105-drm-qxl-use-kmalloc_array-to-alloc-reloc_info-in-qxl.patch"
SRC_URI += "file://1106-drm-radeon-use-post-decrement-in-error-handling.patch"
SRC_URI += "file://1107-drm-No-Op-redundant-calls-to-drm_vblank_off-v2.patch"
SRC_URI += "file://1108-drm-Prevent-vblank-counter-bumps-1-with-active-vblan.patch"
SRC_URI += "file://1109-drm-Fix-drm_vblank_pre-post_modeset-regression-from-.patch"
SRC_URI += "file://1110-drm-Fix-treatment-of-drm_vblank_offdelay-in-drm_vbla.patch"
SRC_URI += "file://1111-drm-radeon-Don-t-hang-in-radeon_flip_work_func-on-di.patch"
SRC_URI += "file://1112-drm-radeon-pm-adjust-display-configuration-after-pow.patch"
SRC_URI += "file://1113-make-sure-that-freeing-shmem-fast-symlinks-is-RCU-de.patch"
SRC_URI += "file://1114-toshiba_acpi-Fix-blank-screen-at-boot-if-transflecti.patch"
SRC_URI += "file://1115-ideapad-laptop-Add-Lenovo-ideapad-Y700-17ISK-to-no_h.patch"
SRC_URI += "file://1116-ideapad-laptop-Add-Lenovo-Yoga-700-to-no_hw_rfkill-d.patch"
SRC_URI += "file://1117-uapi-update-install-list-after-nvme.h-rename.patch"
SRC_URI += "file://1118-lib-sw842-select-crc32.patch"
SRC_URI += "file://1119-ACPI-video-Add-disable_backlight_sysfs_if-quirk-for-.patch"
SRC_URI += "file://1120-ACPI-video-Add-disable_backlight_sysfs_if-quirk-for-.patch"
SRC_URI += "file://1121-ACPI-Revert-ACPI-video-Add-Dell-Inspiron-5737-to-the.patch"
SRC_URI += "file://1122-ACPI-PCI-hotplug-unlock-in-error-path-in-acpiphp_ena.patch"
SRC_URI += "file://1123-nfit-fix-multi-interface-dimm-handling-acpi6.1-compa.patch"
SRC_URI += "file://1124-dmaengine-dw-fix-cyclic-transfer-setup.patch"
SRC_URI += "file://1125-dmaengine-dw-fix-cyclic-transfer-callbacks.patch"
SRC_URI += "file://1126-dmaengine-at_xdmac-fix-resume-for-cyclic-transfers.patch"
SRC_URI += "file://1127-dmaengine-dw-disable-BLOCK-IRQs-for-non-cyclic-xfer.patch"
SRC_URI += "file://1128-IB-cm-Fix-a-recently-introduced-deadlock.patch"
SRC_URI += "file://1129-IB-qib-fix-mcast-detach-when-qp-not-attached.patch"
SRC_URI += "file://1130-IB-qib-Support-creating-qps-with-GFP_NOIO-flag.patch"
SRC_URI += "file://1131-IB-mlx5-Expose-correct-maximum-number-of-CQE-capacit.patch"
SRC_URI += "file://1132-Thermal-initialize-thermal-zone-device-correctly.patch"
SRC_URI += "file://1133-Thermal-handle-thermal-zone-device-properly-during-s.patch"
SRC_URI += "file://1134-Thermal-do-thermal-zone-update-after-a-cooling-devic.patch"
SRC_URI += "file://1135-hwmon-dell-smm-Blacklist-Dell-Studio-XPS-8000.patch"
SRC_URI += "file://1136-hwmon-gpio-fan-Remove-un-necessary-speed_index-looku.patch"
SRC_URI += "file://1137-hwmon-ads1015-Handle-negative-conversion-values-corr.patch"
SRC_URI += "file://1138-cpufreq-pxa2xx-fix-pxa_cpufreq_change_voltage-protot.patch"
SRC_URI += "file://1139-cpufreq-Fix-NULL-reference-crash-while-accessing-pol.patch"
SRC_URI += "file://1140-seccomp-always-propagate-NO_NEW_PRIVS-on-tsync.patch"
SRC_URI += "file://1141-libceph-fix-ceph_msg_revoke.patch"
SRC_URI += "file://1142-libceph-don-t-bail-early-from-try_read-when-skipping.patch"
SRC_URI += "file://1143-libceph-use-the-right-footer-size-when-skipping-a-me.patch"
SRC_URI += "file://1144-libceph-don-t-spam-dmesg-with-stray-reply-warnings.patch"
SRC_URI += "file://1145-sd-Optimal-I-O-size-is-in-bytes-not-sectors.patch"
SRC_URI += "file://1146-Staging-speakup-Fix-getting-port-information.patch"
SRC_URI += "file://1147-Revert-Staging-panel-usleep_range-is-preferred-over-.patch"
SRC_URI += "file://1148-cdc-acm-exclude-Samsung-phone-04e8-685d.patch"
SRC_URI += "file://1149-perf-stat-Do-not-clean-event-s-private-stats.patch"
SRC_URI += "file://1150-tick-nohz-Set-the-correct-expiry-when-switching-to-n.patch"
SRC_URI += "file://1151-rfkill-fix-rfkill_fop_read-wait_event-usage.patch"
SRC_URI += "file://1152-mac80211-Requeue-work-after-scan-complete-for-all-VI.patch"
SRC_URI += "file://1153-workqueue-handle-NUMA_NO_NODE-for-unbound-pool_workq.patch"
SRC_URI += "file://1154-Revert-workqueue-make-sure-delayed-work-run-in-local.patch"
SRC_URI += "file://1155-ALSA-hda-Apply-clock-gate-workaround-to-Skylake-too.patch"
SRC_URI += "file://1156-ALSA-hda-Fixing-background-noise-on-Dell-Inspiron-31.patch"
SRC_URI += "file://1157-target-Fix-LUN_RESET-active-I-O-handling-for-ACK_KRE.patch"
SRC_URI += "file://1158-target-Fix-LUN_RESET-active-TMR-descriptor-handling.patch"
SRC_URI += "file://1159-target-Fix-TAS-handling-for-multi-session-se_node_ac.patch"
SRC_URI += "file://1160-target-Fix-remote-port-TMR-ABORT-se_cmd-fabric-stop.patch"
SRC_URI += "file://1161-target-Fix-race-with-SCF_SEND_DELAYED_TAS-handling.patch"
SRC_URI += "file://1162-spi-atmel-fix-gpio-chip-select-in-case-of-non-DT-pla.patch"
SRC_URI += "file://1163-libata-fix-sff-host-state-machine-locking-while-poll.patch"
SRC_URI += "file://1164-ARCv2-STAR-9000950267-Handle-return-from-intr-to-Del.patch"
SRC_URI += "file://1165-ARCv2-SMP-Emulate-IPI-to-self-using-software-trigger.patch"
SRC_URI += "file://1166-PCI-AER-Flush-workqueue-on-device-remove-to-avoid-us.patch"
SRC_URI += "file://1167-cpuset-make-mm-migration-asynchronous.patch"
SRC_URI += "file://1168-cgroup-make-sure-a-parent-css-isn-t-offlined-before-.patch"
SRC_URI += "file://1169-writeback-keep-superblock-pinned-during-cgroup-write.patch"
SRC_URI += "file://1170-phy-core-fix-wrong-err-handle-for-phy_power_on.patch"
SRC_URI += "file://1171-i2c-i801-Adding-Intel-Lewisburg-support-for-iTCO.patch"
SRC_URI += "file://1172-bio-return-EINTR-if-copying-to-user-space-got-interr.patch"
SRC_URI += "file://1173-block-fix-use-after-free-in-dio_bio_complete.patch"
SRC_URI += "file://1174-nfs-fix-nfs_size_to_loff_t.patch"
SRC_URI += "file://1175-NFSv4-Fix-a-dentry-leak-on-alias-use.patch"
SRC_URI += "file://1176-of-irq-Fix-msi-map-calculation-for-nonzero-rid-base.patch"
SRC_URI += "file://1177-KVM-async_pf-do-not-warn-on-page-allocation-failures.patch"
SRC_URI += "file://1178-KVM-arm-arm64-vgic-Ensure-bitmaps-are-long-enough.patch"
SRC_URI += "file://1179-KVM-x86-fix-missed-hardware-breakpoints.patch"
SRC_URI += "file://1180-KVM-x86-MMU-fix-ubsan-index-out-of-range-warning.patch"
SRC_URI += "file://1181-tracing-Fix-showing-function-event-in-available_even.patch"
SRC_URI += "file://1182-sunrpc-cache-fix-off-by-one-in-qword_get.patch"
SRC_URI += "file://1183-kernel-resource.c-fix-muxed-resource-handling-in-__r.patch"
SRC_URI += "file://1184-do_last-don-t-let-a-bogus-return-value-from-open-et..patch"
SRC_URI += "file://1185-ARM-OMAP2-Fix-onenand-initialization-to-avoid-filesy.patch"
SRC_URI += "file://1186-ARM-at91-dt-fix-typo-in-sama5d2-pinmux-descriptions.patch"
SRC_URI += "file://1187-xen-arm-correctly-handle-DMA-mapping-of-compound-pag.patch"
SRC_URI += "file://1188-xen-scsiback-correct-frontend-counting.patch"
SRC_URI += "file://1189-xen-pciback-Check-PF-instead-of-VF-for-PCI_COMMAND_M.patch"
SRC_URI += "file://1190-xen-pciback-Save-the-number-of-MSI-X-entries-to-be-c.patch"
SRC_URI += "file://1191-xen-pcifront-Fix-mysterious-crashes-when-NUMA-locali.patch"
SRC_URI += "file://1192-should_follow_link-validate-d_seq-after-having-decid.patch"
SRC_URI += "file://1193-do_last-ELOOP-failure-exit-should-be-done-after-leav.patch"
SRC_URI += "file://1194-hpfs-don-t-truncate-the-file-when-delete-fails.patch"
SRC_URI += "file://1195-x86-irq-Call-chip-irq_set_affinity-in-proper-context.patch"
SRC_URI += "file://1196-x86-irq-Fix-a-race-in-x86_vector_free_irqs.patch"
SRC_URI += "file://1197-x86-irq-Validate-that-irq-descriptor-is-still-active.patch"
SRC_URI += "file://1198-x86-irq-Do-not-use-apic_chip_data.old_domain-as-temp.patch"
SRC_URI += "file://1199-x86-irq-Reorganize-the-return-path-in-assign_irq_vec.patch"
SRC_URI += "file://1200-x86-irq-Reorganize-the-search-in-assign_irq_vector.patch"
SRC_URI += "file://1201-x86-irq-Check-vector-allocation-early.patch"
SRC_URI += "file://1202-x86-irq-Copy-vectormask-instead-of-an-AND-operation.patch"
SRC_URI += "file://1203-x86-irq-Get-rid-of-code-duplication.patch"
SRC_URI += "file://1204-x86-irq-Remove-offline-cpus-from-vector-cleanup.patch"
SRC_URI += "file://1205-x86-irq-Clear-move_in_progress-before-sending-cleanu.patch"
SRC_URI += "file://1206-x86-irq-Remove-the-cpumask-allocation-from-send_clea.patch"
SRC_URI += "file://1207-x86-irq-Remove-outgoing-CPU-from-vector-cleanup-mask.patch"
SRC_URI += "file://1208-x86-irq-Call-irq_force_move_complete-with-irq-descri.patch"
SRC_URI += "file://1209-x86-irq-Plug-vector-cleanup-race.patch"
SRC_URI += "file://1210-IB-cma-Fix-RDMA-port-validation-for-iWarp.patch"
SRC_URI += "file://1211-iwlwifi-dvm-fix-WoWLAN.patch"
SRC_URI += "file://1212-iwlwifi-pcie-properly-configure-the-debug-buffer-siz.patch"
SRC_URI += "file://1213-iwlwifi-update-and-fix-7265-series-PCI-IDs.patch"
SRC_URI += "file://1214-iwlwifi-mvm-don-t-allow-sched-scans-without-matches-.patch"
SRC_URI += "file://1215-Revert-UBUNTU-SAUCE-bcache-prevent-crash-on-changing.patch"
SRC_URI += "file://1216-bcache-prevent-crash-on-changing-writeback_running.patch"
SRC_URI += "file://1217-Linux-4.4.4.patch"
SRC_URI += "file://1218-net-mlx4_core-Set-UAR-page-size-to-4KB-regardless-of.patch"
SRC_URI += "file://1219-drm-amdgpu-use-src-in-Makefile-v2.patch"
SRC_URI += "file://1220-drm-radeon-constify-radeon_asic_ring-structures.patch"
SRC_URI += "file://1221-drm-amdgpu-add-a-callback-for-reading-the-bios-from-.patch"
SRC_URI += "file://1222-drm-amdgpu-add-read_bios_from_rom-callback-for-CI-pa.patch"
SRC_URI += "file://1223-drm-amdgpu-add-read_bios_from_rom-callback-for-VI-pa.patch"
SRC_URI += "file://1224-drm-amdgpu-Use-new-read-bios-from-rom-callback.patch"
SRC_URI += "file://1225-drm-amdgpu-Use-unlocked-gem-unreferencing.patch"
SRC_URI += "file://1226-drm-radeon-Use-unlocked-gem-unreferencing.patch"
SRC_URI += "file://1227-drm-amd-add-new-gfx8-register-definitions-for-EDC.patch"
SRC_URI += "file://1228-drm-amdgpu-add-EDC-support-for-CZ-v3.patch"
SRC_URI += "file://1229-drm-amd-abstract-kernel-rq-and-normal-rq-to-priority.patch"
SRC_URI += "file://1230-drm-amdgpu-gfx8-Enable-interrupt-on-ME1_PIPE3.patch"
SRC_URI += "file://1231-drm-amdgpu-gfx8-update-PA_SC_RASTER_CONFIG-PKR_MAP-o.patch"
SRC_URI += "file://1232-drm-amdgpu-update-rev-id-register-for-VI.patch"
SRC_URI += "file://1233-drm-amdgpu-add-more-debugging-output-for-driver-fail.patch"
SRC_URI += "file://1234-drm-amdgpu-add-entity-only-when-first-job-come.patch"
SRC_URI += "file://1235-drm-amdgpu-handle-error-case-for-ctx.patch"
SRC_URI += "file://1236-drm-amdgpu-unify-AMDGPU_CTX_MAX_CS_PENDING-and-amdgp.patch"
SRC_URI += "file://1237-drm-amdgpu-change-default-sched-jobs-to-32.patch"
SRC_URI += "file://1238-drm-amdgpu-limit-visible-vram-if-it-s-smaller-than-t.patch"
SRC_URI += "file://1239-drm-amdgpu-restrict-the-sched-jobs-number-to-power-o.patch"
SRC_URI += "file://1240-drm-amdgpu-put-VM-page-tables-directly-into-duplicat.patch"
SRC_URI += "file://1241-drm-amdgpu-split-VM-PD-and-PT-handling-during-CS.patch"
SRC_URI += "file://1242-drm-amdgpu-keep-the-PTs-validation-list-in-the-VM-v2.patch"
SRC_URI += "file://1243-drm-radeon-Update-radeon_get_vblank_counter_kms.patch"
SRC_URI += "file://1244-drm-radeon-only-increment-sync_seq-when-a-fence-is-r.patch"
SRC_URI += "file://1245-drm-fb-helper-Use-proper-plane-mask-for-fb-cleanup.patch"
SRC_URI += "file://1246-drm-amdgpu-fix-dp-link-rate-selection-v2.patch"
SRC_URI += "file://1247-drm-radeon-fix-dp-link-rate-selection-v2.patch"
SRC_URI += "file://1248-drm-amdgpu-share-struct-amdgpu_pm_state_type-with-po.patch"
SRC_URI += "file://1249-drm-amdgpu-mv-some-definition-from-amdgpu_acpi.c-to-.patch"
SRC_URI += "file://1250-drm-amdgpu-mv-amdgpu_acpi.h-to-amd-include-amd_acpi..patch"
SRC_URI += "file://1251-drm-amdgpu-implement-new-cgs-interface-for-acpi-func.patch"
SRC_URI += "file://1252-drm-amdgpu-implement-cgs-interface-to-query-system-i.patch"
SRC_URI += "file://1253-drm-amdgpu-add-new-cgs-interface-to-get-display-info.patch"
SRC_URI += "file://1254-drm-amd-powerplay-add-basic-powerplay-framework.patch"
SRC_URI += "file://1255-drm-amdgpu-disable-legacy-path-of-firmware-check-if-.patch"
SRC_URI += "file://1256-drm-amdgpu-export-amd_powerplay_func-to-amdgpu-and-o.patch"
SRC_URI += "file://1257-drm-amd-powerplay-add-SMU-manager-sub-component.patch"
SRC_URI += "file://1258-drm-amd-powerplay-add-hardware-manager-sub-component.patch"
SRC_URI += "file://1259-UBUNTU-SAUCE-amd-Include-errno.h.patch"
SRC_URI += "file://1260-drm-amd-powerplay-add-Carrizo-smu-support.patch"
SRC_URI += "file://1261-drm-amd-powerplay-add-Carrizo-dpm-support.patch"
SRC_URI += "file://1262-drm-amd-powerplay-add-CG-and-PG-support-for-carrizo.patch"
SRC_URI += "file://1263-drm-amd-powerplay-add-event-manager-sub-component.patch"
SRC_URI += "file://1264-drm-amd-powerplay-implement-functions-of-amd_powerpl.patch"
SRC_URI += "file://1265-drm-amd-powerplay-Add-ixSWRST_COMMAND_1-in-bif_5_0_d.patch"
SRC_URI += "file://1266-drm-amd-powerplay-Move-smu7-.h-from-amdgpu-to-powerp.patch"
SRC_URI += "file://1267-drm-amd-powerplay-add-header-file-for-tonga-smu-and-.patch"
SRC_URI += "file://1268-drm-amd-powerplay-Add-Tonga-SMU-support.patch"
SRC_URI += "file://1269-drm-amd-powerplay-add-Tonga-dpm-support-v3.patch"
SRC_URI += "file://1270-drm-amd-powerplay-add-update-headers-for-Fiji-SMU-an.patch"
SRC_URI += "file://1271-drm-amd-powerplay-update-atomctrl-for-fiji.patch"
SRC_URI += "file://1272-drm-amd-powerplay-add-Fiji-SMU-support.patch"
SRC_URI += "file://1273-drm-amd-powerplay-add-Fiji-DPM-support.patch"
SRC_URI += "file://1274-drm-amdgpu-add-amdgpu.powerplay-module-option.patch"
SRC_URI += "file://1275-drm-amd-amdgpu-enable-powerplay-and-smc-firmware-loa.patch"
SRC_URI += "file://1276-drm-amdgpu-powerplay-add-function-point-in-hwmgr_fun.patch"
SRC_URI += "file://1277-drm-amdgpu-poweprlay-export-program-display-gap-func.patch"
SRC_URI += "file://1278-drm-amdgpu-powerplay-implement-pem_task-for-display_.patch"
SRC_URI += "file://1279-drm-amdgpu-powerplay-program-display-gap-for-tonga.patch"
SRC_URI += "file://1280-drm-amdgpu-enable-powerplay-module-by-default-for-to.patch"
SRC_URI += "file://1281-drm-amdgpu-enable-powerplay-module-by-default-for-fi.patch"
SRC_URI += "file://1282-drm-amdgpu-powerplay-add-some-definition-for-other-i.patch"
SRC_URI += "file://1283-drm-amd-powerplay-add-new-function-point-in-hwmgr_fu.patch"
SRC_URI += "file://1284-drm-amd-powerplay-Add-CG-and-PG-support-for-tonga.patch"
SRC_URI += "file://1285-drm-amdgpu-powerplay-add-new-function-point-in-hwmgr.patch"
SRC_URI += "file://1286-drm-amdgpu-powerplay-mv-ppinterrupt.h-to-inc-folder-.patch"
SRC_URI += "file://1287-drm-amdgpu-powerplay-add-thermal-control-interface-i.patch"
SRC_URI += "file://1288-drm-amdgpu-powerplay-enable-thermal-interrupt-task-i.patch"
SRC_URI += "file://1289-drm-amdgpu-powerplay-implement-thermal-control-for-t.patch"
SRC_URI += "file://1290-drm-amdgpu-powerplay-implement-fan-control-interface.patch"
SRC_URI += "file://1291-drm-amdgpu-export-fan-control-functions-to-amdgpu.patch"
SRC_URI += "file://1292-drm-amdgpu-enable-sysfs-interface-for-powerplay.patch"
SRC_URI += "file://1293-drm-amdgpu-support-per-device-powerplay-enablement-v.patch"
SRC_URI += "file://1294-drm-amd-powerplay-add-and-export-hwmgr-interface-to-.patch"
SRC_URI += "file://1295-drm-amd-powerplay-implement-new-funcs-to-check-curre.patch"
SRC_URI += "file://1296-drm-amd-powerplay-refine-the-logic-of-whether-need-t.patch"
SRC_URI += "file://1297-drm-amd-powerplay-tonga-enable-pcie-and-mclk-forcing.patch"
SRC_URI += "file://1298-drm-amd-powerplay-fiji-enable-pcie-and-mclk-forcing-.patch"
SRC_URI += "file://1299-drm-amdgpu-extract-pcie-helpers-to-common-header.patch"
SRC_URI += "file://1300-drm-add-drm_pcie_get_max_link_width-helper-v2.patch"
SRC_URI += "file://1301-drm-amdgpu-store-pcie-gen-mask-and-link-width.patch"
SRC_URI += "file://1302-drm-amdgpu-cgs-add-sys-info-query-for-pcie-gen-and-l.patch"
SRC_URI += "file://1303-drm-amdgpu-powerplay-tonga-query-supported-pcie-info.patch"
SRC_URI += "file://1304-drm-amdgpu-powerplay-fiji-query-supported-pcie-info-.patch"
SRC_URI += "file://1305-drm-amd-powerplay-fix-boolreturn.cocci-warnings.patch"
SRC_URI += "file://1306-drm-amd-powerplay-tonga-Add-UVD-DPM-init.patch"
SRC_URI += "file://1307-drm-amd-amdgpu-add-gfx-clock-gating-support-for-Fiji.patch"
SRC_URI += "file://1308-drm-amd-amdgpu-add-gmc-clock-gating-support-for-Fiji.patch"
SRC_URI += "file://1309-drm-amdgpu-add-sdma-clock-gating-support-for-Fiji.patch"
SRC_URI += "file://1310-drm-amd-powerplay-add-parts-of-system-clock-gating-s.patch"
SRC_URI += "file://1311-drm-amd-powerplay-enable-clock-gating-for-Fiji.patch"
SRC_URI += "file://1312-drm-amd-powerplay-add-atomctrl-function-to-calculate.patch"
SRC_URI += "file://1313-drm-amd-powerplay-implement-smc-state-upload-for-CZ.patch"
SRC_URI += "file://1314-drm-amd-powerplay-fix-warning-of-cast-to-pointer-fro.patch"
SRC_URI += "file://1315-drm-amd-powerplay-fix-warning-of-cast-to-pointer-fro.patch"
SRC_URI += "file://1316-drm-amd-powerplay-add-new-function-point-in-hwmgr.patch"
SRC_URI += "file://1317-drm-amd-powerplay-add-smc-msg-for-NB-P-State-switch.patch"
SRC_URI += "file://1318-drm-amd-powerplay-export-interface-to-DAL-to-init-ch.patch"
SRC_URI += "file://1319-drm-amd-powerplay-enable-set_cpu_power_state-task.-v.patch"
SRC_URI += "file://1320-drm-amd-powerplay-enable-disable-NB-pstate-feature-f.patch"
SRC_URI += "file://1321-drm-amd-powerplay-Add-PPLib-debug-print-macro.patch"
SRC_URI += "file://1322-drm-amdgpu-rename-tonga_smumgr.h-to-tonga_smum.h.patch"
SRC_URI += "file://1323-drm-amdgpu-rename-fiji_smumgr.h-to-fiji_smum.h.patch"
SRC_URI += "file://1324-drm-amd-powerplay-add-multimedia-power-gating-suppor.patch"
SRC_URI += "file://1325-drm-amd-amdgpu-add-uvd6.0-clock-gating-support.-v2.patch"
SRC_URI += "file://1326-drm-amd-amdgpu-add-vce3.0-clock-gating-support.-v2.patch"
SRC_URI += "file://1327-drm-amd-amdgpu-enable-uvd-vce-clock-gating-for-Fiji.patch"
SRC_URI += "file://1328-drm-amdgpu-Prepare-DKMS-build-for-powerplay-module.patch"
SRC_URI += "file://1329-drm-amd-powerplay-add-display-configeration-changed-.patch"
SRC_URI += "file://1330-drm-amd-powerplay-Add-thermal-protection-support-for.patch"
SRC_URI += "file://1331-drm-amd-powerplay-Fix-a-bug-in-fan-control-setting-d.patch"
SRC_URI += "file://1332-drm-amd-powerplay-add-functions-set-get_fan_control_.patch"
SRC_URI += "file://1333-drm-amd-powerplay-add-functions-set-get_fan_control_.patch"
SRC_URI += "file://1334-drm-amd-powerplay-fix-boolreturn.cocci-warnings.patch"
SRC_URI += "file://1335-drm-amd-powerplay-fix-bug-that-dpm-funcs-in-debugfs-.patch"
SRC_URI += "file://1336-drm-amd-powerplay-check-whether-enable-dpm-in-powerp.patch"
SRC_URI += "file://1337-drm-amd-powerplay-move-shared-function-of-vi-to-hwmg.patch"
SRC_URI += "file://1338-drm-amdgpu-powerplay-enable-sysfs-and-debugfs-interf.patch"
SRC_URI += "file://1339-drm-amd-powerplay-display-gpu-load-when-print-perfor.patch"
SRC_URI += "file://1340-drm-powerplay-add-debugging-output-to-tonga_processp.patch"
SRC_URI += "file://1341-drm-powerplay-add-debugging-output-to-processpptable.patch"
SRC_URI += "file://1342-drm-powerplay-hwmgr-log-errors-in-tonga_hwmgr_backen.patch"
SRC_URI += "file://1343-drm-amd-powerplay-Don-t-return-an-error-if-fan-table.patch"
SRC_URI += "file://1344-amd-powerplay-Implement-get-dal-power-level.patch"
SRC_URI += "file://1345-amd-powerplay-Fix-get-dal-power-level.patch"
SRC_URI += "file://1346-amd-powerplay-Add-structures-required-to-report-conf.patch"
SRC_URI += "file://1347-drm-amdgpu-powerplay-Program-a-calculated-value-as-D.patch"
SRC_URI += "file://1348-drm-amd-powerplay-add-point-check-to-avoid-NULL-poin.patch"
SRC_URI += "file://1349-drm-amd-powerplay-check-whether-need-to-enable-therm.patch"
SRC_URI += "file://1350-drm-amd-powerplay-show-gpu-load-when-print-gpu-perfo.patch"
SRC_URI += "file://1351-drm-powerplay-use-div64_s64-instead-of-do_div.patch"
SRC_URI += "file://1352-drm-amd-powerplay-fix-a-reversed-condition.patch"
SRC_URI += "file://1353-drm-amdgpu-cgs-cleanup-some-indenting.patch"
SRC_URI += "file://1354-drm-amd-powerplay-precedence-bug-in-init_non_clock_f.patch"
SRC_URI += "file://1355-drm-amdgpu-fix-NULL-in-vm_grab_id-while-S3-back.patch"
SRC_URI += "file://1356-drm-amd-powerplay-fix-bug-that-NULL-checks-are-rever.patch"
SRC_URI += "file://1357-drm-amd-powerplay-fix-Smatch-static-checker-warnings.patch"
SRC_URI += "file://1358-drm-amd-powerplay-fix-Smatch-static-checker-warnings.patch"
SRC_URI += "file://1359-drm-amd-powerplay-add-powerplay-valid-check-to-avoid.patch"
SRC_URI += "file://1360-drm-amd-powerplay-Reload-and-initialize-the-smc-firm.patch"
SRC_URI += "file://1361-drm-amdgpu-Show-gpu-load-when-display-gpu-performanc.patch"
SRC_URI += "file://1362-drm-amdgpu-Show-gpu-load-when-display-gpu-performanc.patch"
SRC_URI += "file://1363-drm-amdgpu-fix-hex-decimal-bug-when-show-gpu-load.patch"
SRC_URI += "file://1364-drm-amd-powerplay-add-thermal-control-task-when-resu.patch"
SRC_URI += "file://1365-drm-amd-powerplay-enable-set-boot-state-task.patch"
SRC_URI += "file://1366-drm-amd-powerplay-enable-power-down-asic-task.-v2.patch"
SRC_URI += "file://1367-drm-amd-powerplay-implement-power-down-asic-task-for.patch"
SRC_URI += "file://1368-drm-amdgpu-add-warning-to-amdgpu_bo_gpu_offset-v2.patch"
SRC_URI += "file://1369-drm-amdgpu-cgs-add-an-interface-to-access-PCI-resour.patch"
SRC_URI += "file://1370-drm-amdgpu-add-irq-domain-support.patch"
SRC_URI += "file://1371-drm-amdgpu-powerplay-include-asm-div64.h-for-do_div.patch"
SRC_URI += "file://1372-drm-sysfs-use-kobj_to_dev.patch"
SRC_URI += "file://1373-drm-amd-powerplay-fix-static-checker-warning-for-ret.patch"
SRC_URI += "file://1374-drm-amdgpu-cz-add-code-to-enable-forcing-UVD-clocks.patch"
SRC_URI += "file://1375-drm-amdgpu-cz-add-code-to-enable-forcing-VCE-clocks.patch"
SRC_URI += "file://1376-drm-amdgpu-cz-force-uvd-clocks-when-sclks-are-forced.patch"
SRC_URI += "file://1377-drm-amdgpu-cz-force-vce-clocks-when-sclks-are-forced.patch"
SRC_URI += "file://1378-drm-amdgpu-use-kobj_to_dev.patch"
SRC_URI += "file://1379-drm-radeon-use-kobj_to_dev.patch"
SRC_URI += "file://1380-drm-ttm-fix-adding-foreign-BOs-to-the-LRU-during-ini.patch"
SRC_URI += "file://1381-drm-ttm-fix-adding-foreign-BOs-to-the-swap-LRU.patch"
SRC_URI += "file://1382-drm-ttm-add-ttm_bo_move_to_lru_tail-function-v2.patch"
SRC_URI += "file://1383-drm-amdgpu-move-VM-page-tables-to-the-LRU-end-on-CS-.patch"
SRC_URI += "file://1384-drm-amdgpu-validate-duplicates-first.patch"
SRC_URI += "file://1385-drm-amdgpu-add-missing-irq.h-include.patch"
SRC_URI += "file://1386-drm-fb_cma_helper-Remove-implicit-call-to-disable_un.patch"
SRC_URI += "file://1387-drm-amdgpu-Add-some-tweaks-to-gfx-8-soft-reset.patch"
SRC_URI += "file://1388-amdkfd-don-t-open-code-memdup_user.patch"
SRC_URI += "file://1389-amdkfd-Copy-from-the-proper-user-command-pointer.patch"
SRC_URI += "file://1390-drm-amdgpu-Use-drm_calloc_large-for-VM-page_tables-a.patch"
SRC_URI += "file://1391-amd-powerplay-disable-powerplay-by-default-initially.patch"
SRC_URI += "file://1392-drm-amdgpu-Allow-the-driver-to-load-if-amdgpu.powerp.patch"
SRC_URI += "file://1393-drm-atomic-helper-Export-framebuffer_changed.patch"
SRC_URI += "file://1394-drm-amd-amdgpu-Improve-amdgpu_dpm-macros-to-avoid-un.patch"
SRC_URI += "file://1395-drm-amdgpu-add-a-message-to-indicate-when-powerplay-.patch"
SRC_URI += "file://1396-drm-amdgpu-fix-next_rptr-handling-for-debugfs.patch"
SRC_URI += "file://1397-drm-radeon-Ensure-radeon-bo-is-unreserved-in-radeon_.patch"
SRC_URI += "file://1398-drm-radeon-only-init-fbdev-if-we-have-connectors.patch"
SRC_URI += "file://1399-drm-amdgpu-don-t-init-fbdev-if-we-don-t-have-any-con.patch"
SRC_URI += "file://1400-drm-amd-powerplay-Update-SMU-firmware-loading-for-St.patch"
SRC_URI += "file://1401-drm-amdgpu-fix-non-ANSI-declaration-of-amdgpu_amdkfd.patch"
SRC_URI += "file://1402-drm-amdkfd-Remove-unnecessary-cast-in-kfree.patch"
SRC_URI += "file://1403-drm-amdgpu-only-move-pt-bos-in-LRU-list-on-success.patch"
SRC_URI += "file://1404-drm-amdgpu-mask-out-WC-from-BO-on-unsupported-arches.patch"
SRC_URI += "file://1405-drm-amdgpu-gfx8-enable-cp-inst-reg-error-interrupts.patch"
SRC_URI += "file://1406-drm-amdgpu-gfx7-enable-cp-inst-reg-error-interrupts.patch"
SRC_URI += "file://1407-drm-amdgpu-load-MEC-ucode-manually-on-iceland.patch"
SRC_URI += "file://1408-drm-amdgpu-disable-uvd-and-vce-clockgating-on-Fiji.patch"
SRC_URI += "file://1409-drm-amdgpu-add-pcie-cap-module-parameters-v2.patch"
SRC_URI += "file://1410-drm-amdgpu-cik-don-t-mess-with-aspm-if-gpu-is-root-b.patch"
SRC_URI += "file://1411-drm-amdgpu-dpm-ci-switch-over-to-the-common-pcie-cap.patch"
SRC_URI += "file://1412-drm-amdgpu-handle-uvd-pg-flags-properly.patch"
SRC_URI += "file://1413-drm-amdgpu-handle-vce-pg-flags-properly.patch"
SRC_URI += "file://1414-drm-amdgpu-clean-up-vce-pg-flags-for-cz-st.patch"
SRC_URI += "file://1415-drm-amdgpu-be-consistent-with-uvd-cg-flags.patch"
SRC_URI += "file://1416-drm-amd-powerplay-cz-disable-uvd-pg.patch"
SRC_URI += "file://1417-drm-amd-powerplay-cz-disable-vce-pg.patch"
SRC_URI += "file://1418-drm-amd-powerplay-tonga-disable-uvd-pg.patch"
SRC_URI += "file://1419-drm-amd-powerplay-tonga-disable-vce-pg.patch"
SRC_URI += "file://1420-drm-amdgpu-add-a-cgs-interface-to-fetch-cg-and-pg-fl.patch"
SRC_URI += "file://1421-drm-amdgpu-remove-unused-cg-defines.patch"
SRC_URI += "file://1422-drma-dmgpu-move-cg-and-pg-flags-into-shared-headers.patch"
SRC_URI += "file://1423-drm-amdgpu-tonga-plumb-pg-flags-through-to-powerplay.patch"
SRC_URI += "file://1424-drm-amdgpu-cz-plumb-pg-flags-through-to-powerplay.patch"
SRC_URI += "file://1425-UBUNTU-SAUCE-drm-amdgpu-cz-enable-disable-vce-dpm-ev.patch"
SRC_URI += "file://1426-net-thunderx-Fix-for-Qset-error-due-to-CQ-full.patch"
SRC_URI += "file://1427-ahci-Workaround-for-ThunderX-Errata-22536.patch"
SRC_URI += "file://1428-arm64-Add-workaround-for-Cavium-erratum-27456.patch"
SRC_URI += "file://1429-Revert-drm-radeon-call-hpd_irq_event-on-resume.patch"
SRC_URI += "file://1430-tipc-fix-nullptr-crash-during-subscription-cancel.patch"
SRC_URI += "file://1431-drm-i915-Fix-hpd-live-status-bits-for-g4x.patch"
SRC_URI += "file://1432-tpm_tis-further-simplify-calculation-of-ordinal-dura.patch"
SRC_URI += "file://1433-tpm_tis-Use-devm_free_irq-not-free_irq.patch"
SRC_URI += "file://1434-tpm_tis-Ensure-interrupts-are-disabled-when-the-driv.patch"
SRC_URI += "file://1435-tpm-rework-tpm_get_timeouts.patch"
SRC_URI += "file://1436-tpm_tis-Get-rid-of-the-duplicate-IRQ-probing-code.patch"
SRC_URI += "file://1437-tpm_tis-Refactor-the-interrupt-setup.patch"
SRC_URI += "file://1438-tpm_tis-Tighten-IRQ-auto-probing.patch"
SRC_URI += "file://1439-tpm_ibmvtpm-properly-handle-interrupted-packet-recep.patch"
SRC_URI += "file://1440-x86-mm-Fix-slow_virt_to_phys-for-X86_PAE-again.patch"
SRC_URI += "file://1441-use-d_seq-to-get-coherency-between-d_inode-and-d_fla.patch"
SRC_URI += "file://1442-drivers-sh-Restore-legacy-clock-domain-on-SuperH-pla.patch"
SRC_URI += "file://1443-Btrfs-fix-deadlock-running-delayed-iputs-at-transact.patch"
SRC_URI += "file://1444-btrfs-Fix-no_space-in-write-and-rm-loop.patch"
SRC_URI += "file://1445-btrfs-async-thread-Fix-a-use-after-free-error-for-tr.patch"
SRC_URI += "file://1446-block-Initialize-max_dev_sectors-to-0.patch"
SRC_URI += "file://1447-PCI-keystone-Fix-MSI-code-that-retrieves-struct-pcie.patch"
SRC_URI += "file://1448-parisc-Fix-ptrace-syscall-number-and-return-value-mo.patch"
SRC_URI += "file://1449-mips-kvm-fix-ioctl-error-handling.patch"
SRC_URI += "file://1450-kvm-x86-Update-tsc-multiplier-on-change.patch"
SRC_URI += "file://1451-fbcon-set-a-default-value-to-blink-interval.patch"
SRC_URI += "file://1452-cifs-fix-out-of-bounds-access-in-lease-parsing.patch"
SRC_URI += "file://1453-CIFS-Fix-SMB2-interim-response-processing-for-read-r.patch"
SRC_URI += "file://1454-vfio-fix-ioctl-error-handling.patch"
SRC_URI += "file://1455-KVM-x86-fix-root-cause-for-missed-hardware-breakpoin.patch"
SRC_URI += "file://1456-arm-arm64-KVM-Fix-ioctl-error-handling.patch"
SRC_URI += "file://1457-iommu-amd-Apply-workaround-for-ATS-write-permission-.patch"
SRC_URI += "file://1458-iommu-amd-Fix-boot-warning-when-device-00-00.0-is-no.patch"
SRC_URI += "file://1459-iommu-vt-d-Use-BUS_NOTIFY_REMOVED_DEVICE-in-hotplug-.patch"
SRC_URI += "file://1460-target-Fix-WRITE_SAME-DISCARD-conversion-to-linux-51.patch"
SRC_URI += "file://1461-drm-ast-Fix-incorrect-register-check-for-DRAM-width.patch"
SRC_URI += "file://1462-drm-radeon-pm-update-current-crtc-info-after-setting.patch"
SRC_URI += "file://1463-drm-amdgpu-pm-update-current-crtc-info-after-setting.patch"
SRC_URI += "file://1464-drm-amdgpu-apply-gfx_v8-fixes-to-gfx_v7-as-well.patch"
SRC_URI += "file://1465-drm-amdgpu-gfx8-specify-which-engine-to-wait-before-.patch"
SRC_URI += "file://1466-drm-amdgpu-return-from-atombios_dp_get_dpcd-only-whe.patch"
SRC_URI += "file://1467-libata-fix-HDIO_GET_32BIT-ioctl.patch"
SRC_URI += "file://1468-libata-Align-ata_device-s-id-on-a-cacheline.patch"
SRC_URI += "file://1469-block-bio-introduce-helpers-to-get-the-1st-and-last-.patch"
SRC_URI += "file://1470-writeback-flush-inode-cgroup-wb-switches-instead-of-.patch"
SRC_URI += "file://1471-Adding-Intel-Lewisburg-device-IDs-for-SATA.patch"
SRC_URI += "file://1472-arm64-vmemmap-use-virtual-projection-of-linear-regio.patch"
SRC_URI += "file://1473-PM-sleep-x86-Fix-crash-on-graph-trace-through-x86-su.patch"
SRC_URI += "file://1474-ata-ahci-don-t-mark-HotPlugCapable-Ports-as-external.patch"
SRC_URI += "file://1475-tracing-Do-not-have-comm-filter-override-event-comm-.patch"
SRC_URI += "file://1476-pata-rb532-cf-get-rid-of-the-irq_to_gpio-call.patch"
SRC_URI += "file://1477-Btrfs-fix-loading-of-orphan-roots-leading-to-BUG_ON.patch"
SRC_URI += "file://1478-Revert-jffs2-Fix-lock-acquisition-order-bug-in-jffs2.patch"
SRC_URI += "file://1479-jffs2-Fix-page-lock-f-sem-deadlock.patch"
SRC_URI += "file://1480-Fix-directory-hardlinks-from-deleted-directories.patch"
SRC_URI += "file://1481-dmaengine-pxa_dma-fix-cyclic-transfers.patch"
SRC_URI += "file://1482-adv7604-fix-tx-5v-detect-regression.patch"
SRC_URI += "file://1483-ALSA-usb-audio-Add-a-quirk-for-Plantronics-DA45.patch"
SRC_URI += "file://1484-ALSA-ctl-Fix-ioctls-for-X32-ABI.patch"
SRC_URI += "file://1485-ALSA-hda-Fix-mic-issues-on-Acer-Aspire-E1-472.patch"
SRC_URI += "file://1486-ALSA-rawmidi-Fix-ioctls-X32-ABI.patch"
SRC_URI += "file://1487-ALSA-timer-Fix-ioctls-for-X32-ABI.patch"
SRC_URI += "file://1488-ALSA-pcm-Fix-ioctls-for-X32-ABI.patch"
SRC_URI += "file://1489-ALSA-seq-oss-Don-t-drain-at-closing-a-client.patch"
SRC_URI += "file://1490-ALSA-hdspm-Fix-wrong-boolean-ctl-value-accesses.patch"
SRC_URI += "file://1491-ALSA-hdsp-Fix-wrong-boolean-ctl-value-accesses.patch"
SRC_URI += "file://1492-ALSA-hdspm-Fix-zero-division.patch"
SRC_URI += "file://1493-ALSA-timer-Fix-broken-compat-timer-user-status-ioctl.patch"
SRC_URI += "file://1494-usb-chipidea-otg-change-workqueue-ci_otg-as-freezabl.patch"
SRC_URI += "file://1495-USB-cp210x-Add-ID-for-Parrot-NMEA-GPS-Flight-Recorde.patch"
SRC_URI += "file://1496-USB-qcserial-add-Dell-Wireless-5809e-Gobi-4G-HSPA-re.patch"
SRC_URI += "file://1497-USB-qcserial-add-Sierra-Wireless-EM74xx-device-ID.patch"
SRC_URI += "file://1498-USB-serial-option-add-support-for-Telit-LE922-PID-0x.patch"
SRC_URI += "file://1499-USB-serial-option-add-support-for-Quectel-UC20.patch"
SRC_URI += "file://1500-MIPS-scache-Fix-scache-init-with-invalid-line-size.patch"
SRC_URI += "file://1501-MIPS-traps-Fix-SIGFPE-information-leak-from-do_ov-an.patch"
SRC_URI += "file://1502-ubi-Fix-out-of-bounds-write-in-volume-update-code.patch"
SRC_URI += "file://1503-i2c-brcmstb-allocate-correct-amount-of-memory-for-re.patch"
SRC_URI += "file://1504-thermal-cpu_cooling-fix-out-of-bounds-access-in-time.patch"
SRC_URI += "file://1505-block-check-virt-boundary-in-bio_will_gap.patch"
SRC_URI += "file://1506-block-get-the-1st-and-last-bvec-via-helpers.patch"
SRC_URI += "file://1507-drm-i915-more-virtual-south-bridge-detection.patch"
SRC_URI += "file://1508-drm-i915-refine-qemu-south-bridge-detection.patch"
SRC_URI += "file://1509-modules-fix-longstanding-proc-kallsyms-vs-module-ins.patch"
SRC_URI += "file://1510-drm-amdgpu-fix-topaz-tonga-gmc-assignment-in-4.4-sta.patch"
SRC_URI += "file://1511-Linux-4.4.5.patch"
SRC_URI += "file://1512-UBUNTU-SAUCE-noup-netfilter-x_tables-check-for-size-.patch"
SRC_URI += "file://1513-UBUNTU-SAUCE-nf-v2-netfilter-x_tables-don-t-rely-on-.patch"
SRC_URI += "file://1514-cpufreq-powernv-Free-chips-on-module-exit.patch"
SRC_URI += "file://1515-cpufreq-powernv-Hot-plug-safe-the-kworker-thread.patch"
SRC_URI += "file://1516-cpufreq-powernv-Remove-cpu_to_chip_id-from-hot-path.patch"
SRC_URI += "file://1517-cpufreq-powernv-tracing-Add-powernv_throttle-tracepo.patch"
SRC_URI += "file://1518-cpufreq-powernv-Replace-pr_info-with-trace-print-for.patch"
SRC_URI += "file://1519-UBUNTU-SAUCE-noup-cpufreq-powernv-Fix-bugs-in-powern.patch"
SRC_URI += "file://1520-ALSA-hda-add-codec-support-for-Kabylake-display-audi.patch"
SRC_URI += "file://1521-UBUNTU-SAUCE-noup-megaraid_sas-Don-t-issue-kill-adap.patch"
SRC_URI += "file://1522-hv_netvsc-use-skb_get_hash-instead-of-a-homegrown-im.patch"
SRC_URI += "file://1523-hv_netvsc-cleanup-netdev-feature-flags-for-netvsc.patch"
SRC_URI += "file://1524-ovl-copy-new-uid-gid-into-overlayfs-runtime-inode.patch"
SRC_URI += "file://1525-sched-numa-Fix-use-after-free-bug-in-the-task_numa_c.patch"
SRC_URI += "file://1526-UVC-Add-support-for-ds4-depth-camera.patch"
SRC_URI += "file://1527-UBUNTU-SAUCE-Dump-stack-when-X.509-certificates-cann.patch"
SRC_URI += "file://1528-mmc-sdhci-Do-not-BUG-on-invalid-vdd.patch"
SRC_URI += "file://1529-mmc-enable-MMC-SD-SDIO-device-to-suspend-resume-asyn.patch"
SRC_URI += "file://1530-mmc-It-is-not-an-error-for-the-card-to-be-removed-wh.patch"
SRC_URI += "file://1531-net-mlx5e-Don-t-try-to-modify-CQ-moderation-if-it-is.patch"
SRC_URI += "file://1532-net-mlx5e-Don-t-modify-CQ-before-it-was-created.patch"
SRC_URI += "file://1533-lib-mpi-Endianness-fix.patch"
SRC_URI += "file://1534-arm64-account-for-sparsemem-section-alignment-when-c.patch"
SRC_URI += "file://1535-ARM-mvebu-fix-overlap-of-Crypto-SRAM-with-PCIe-memor.patch"
SRC_URI += "file://1536-ARM-dts-dra7-do-not-gate-cpsw-clock-due-to-errata-i8.patch"
SRC_URI += "file://1537-ARM-OMAP2-hwmod-Introduce-ti-no-idle-dt-property.patch"
SRC_URI += "file://1538-PCI-Allow-a-NULL-parent-pointer-in-pci_bus_assign_do.patch"
SRC_URI += "file://1539-kvm-cap-halt-polling-at-exactly-halt_poll_ns.patch"
SRC_URI += "file://1540-KVM-VMX-disable-PEBS-before-a-guest-entry.patch"
SRC_URI += "file://1541-KVM-PPC-Book3S-HV-Sanitize-special-purpose-register-.patch"
SRC_URI += "file://1542-KVM-MMU-fix-ept-0-pte.u-1-pte.w-0-CR0.WP-0-CR4.SMEP-.patch"
SRC_URI += "file://1543-KVM-MMU-fix-reserved-bit-check-for-ept-0-CR0.WP-0-CR.patch"
SRC_URI += "file://1544-tracing-Fix-check-for-cpu-online-when-event-is-disab.patch"
SRC_URI += "file://1545-dmaengine-at_xdmac-fix-residue-computation.patch"
SRC_URI += "file://1546-jffs2-reduce-the-breakage-on-recovery-from-halfway-f.patch"
SRC_URI += "file://1547-ncpfs-fix-a-braino-in-OOM-handling-in-ncp_fill_cache.patch"
SRC_URI += "file://1548-ASoC-dapm-Fix-ctl-value-accesses-in-a-wrong-type.patch"
SRC_URI += "file://1549-ASoC-samsung-Use-IRQ-safe-spin-lock-calls.patch"
SRC_URI += "file://1550-ASoC-wm8994-Fix-enum-ctl-accesses-in-a-wrong-type.patch"
SRC_URI += "file://1551-ASoC-wm8958-Fix-enum-ctl-accesses-in-a-wrong-type.patch"
SRC_URI += "file://1552-ovl-ignore-lower-entries-when-checking-purity-of-non.patch"
SRC_URI += "file://1553-ovl-fix-working-on-distributed-fs-as-lower-layer.patch"
SRC_URI += "file://1554-wext-fix-message-delay-ordering.patch"
SRC_URI += "file://1555-cfg80211-wext-fix-message-ordering.patch"
SRC_URI += "file://1556-can-gs_usb-fixed-disconnect-bug-by-removing-erroneou.patch"
SRC_URI += "file://1557-iwlwifi-mvm-inc-pending-frames-counter-also-when-txi.patch"
SRC_URI += "file://1558-mac80211-minstrel-Change-expected-throughput-unit-ba.patch"
SRC_URI += "file://1559-mac80211-fix-use-of-uninitialised-values-in-RX-aggre.patch"
SRC_URI += "file://1560-mac80211-minstrel_ht-set-default-tx-aggregation-time.patch"
SRC_URI += "file://1561-mac80211-minstrel_ht-fix-a-logic-error-in-RTS-CTS-ha.patch"
SRC_URI += "file://1562-mac80211-check-PN-correctly-for-GCMP-encrypted-fragm.patch"
SRC_URI += "file://1563-mac80211-Fix-Public-Action-frame-RX-in-AP-mode.patch"
SRC_URI += "file://1564-gpu-ipu-v3-Do-not-bail-out-on-missing-optional-port-.patch"
SRC_URI += "file://1565-drm-amdgpu-Fix-error-handling-in-amdgpu_flip_work_fu.patch"
SRC_URI += "file://1566-drm-radeon-Fix-error-handling-in-radeon_flip_work_fu.patch"
SRC_URI += "file://1567-Revert-drm-radeon-pm-adjust-display-configuration-af.patch"
SRC_URI += "file://1568-userfaultfd-don-t-block-on-the-last-VM-updates-at-ex.patch"
SRC_URI += "file://1569-ovl-fix-getcwd-failure-after-unsuccessful-rmdir.patch"
SRC_URI += "file://1570-MIPS-Fix-build-error-when-SMP-is-used-without-GIC.patch"
SRC_URI += "file://1571-MIPS-smp.c-Fix-uninitialised-temp_foreign_map.patch"
SRC_URI += "file://1572-block-don-t-optimize-for-non-cloned-bio-in-bio_get_l.patch"
SRC_URI += "file://1573-target-Drop-incorrect-ABORT_TASK-put-for-completed-c.patch"
SRC_URI += "file://1574-ld-version-Fix-awk-regex-compile-failure.patch"
SRC_URI += "file://1575-Linux-4.4.6.patch"
SRC_URI += "file://1576-PCI-generic-Move-structure-definitions-to-separate-h.patch"
SRC_URI += "file://1577-PCI-generic-Add-pci_host_common_probe-based-on-gen_p.patch"
SRC_URI += "file://1578-PCI-generic-Expose-pci_host_common_probe-for-use-by-.patch"
SRC_URI += "file://1579-PCI-thunder-Add-PCIe-host-driver-for-ThunderX-proces.patch"
SRC_URI += "file://1580-PCI-thunder-Add-driver-for-ThunderX-pass-1-2-on-chip.patch"
SRC_URI += "file://1581-ipv4-only-create-late-gso-skb-if-skb-is-already-set-.patch"
SRC_URI += "file://1582-KEYS-Use-the-symbol-value-for-list-size-updated-by-s.patch"
SRC_URI += "file://1583-KEYS-Reserve-an-extra-certificate-symbol-for-inserti.patch"
SRC_URI += "file://1584-UBUNTU-SAUCE-noup-KEYS-Support-for-inserting-a-certi.patch"
SRC_URI += "file://1585-page_to_phys-always-returns-a-multiple-of-PAGE_SIZE.patch"
SRC_URI += "file://1586-Revert-Revert-af_unix-Revert-lock_interruptible-in-s.patch"
SRC_URI += "file://1587-UBUNTU-SAUCE-noup-efi-ARM-arm64-ignore-DT-memory-nod.patch"
SRC_URI += "file://1588-UBUNTU-SAUCE-noup-Documentation-dt-numa-dt-bindings-.patch"
SRC_URI += "file://1589-UBUNTU-SAUCE-noup-of-numa-Add-NUMA-of-binding-implem.patch"
SRC_URI += "file://1590-UBUNTU-SAUCE-noup-arm64-Move-unflatten_device_tree-c.patch"
SRC_URI += "file://1591-UBUNTU-SAUCE-noup-arm64-numa-Add-NUMA-support-for-ar.patch"
SRC_URI += "file://1592-UBUNTU-SAUCE-noup-arm64-mm-numa-Add-NUMA-balancing-s.patch"
SRC_URI += "file://1593-Revert-UBUNTU-SAUCE-Move-replacedby-allocation-into-.patch"
SRC_URI += "file://1594-Revert-UBUNTU-SAUCE-Fixup-__label_update-still-doesn.patch"
SRC_URI += "file://1595-Revert-UBUNTU-SAUCE-fix-audit-no_new_privs-case-for-.patch"
SRC_URI += "file://1596-Revert-UBUNTU-SAUCE-fixup-warning-about-aa_label_vec.patch"
SRC_URI += "file://1597-Revert-UBUNTU-SAUCE-apparmor-fix-refcount-race-when-.patch"
SRC_URI += "file://1598-Revert-UBUNTU-SAUCE-fixup-cast-poison-values-to-remo.patch"
SRC_URI += "file://1599-Revert-UBUNTU-SAUCE-fixup-get-rid-of-unused-var-buil.patch"
SRC_URI += "file://1600-Revert-UBUNTU-SAUCE-fixup-20-23-locking-issue-around.patch"
SRC_URI += "file://1601-Revert-UBUNTU-SAUCE-fixup-make-__share_replacedby-pr.patch"
SRC_URI += "file://1602-Revert-UBUNTU-SAUCE-fix-replacedby-forwarding-is-not.patch"
SRC_URI += "file://1603-Revert-UBUNTU-SAUCE-apparmor-fix-log-of-apparmor-aud.patch"
SRC_URI += "file://1604-Revert-UBUNTU-SAUCE-fixup-cleanup-return-handling-of.patch"
SRC_URI += "file://1605-Revert-UBUNTU-SAUCE-apparmor-fix-ref-count-leak-when.patch"
SRC_URI += "file://1606-Revert-UBUNTU-SAUCE-apparmor-Fix-query-label-file-pe.patch"
SRC_URI += "file://1607-Revert-UBUNTU-SAUCE-apparmor-Don-t-remove-label-on-r.patch"
SRC_URI += "file://1608-Revert-UBUNTU-SAUCE-apparmor-Fix-break-circular-refc.patch"
SRC_URI += "file://1609-Revert-UBUNTU-SAUCE-apparmor-Fix-refcount-bug-when-i.patch"
SRC_URI += "file://1610-Revert-UBUNTU-SAUCE-apparmor-Fix-now-that-insert-can.patch"
SRC_URI += "file://1611-Revert-UBUNTU-SAUCE-apparmor-Fix-refcount-bug-in-piv.patch"
SRC_URI += "file://1612-Revert-UBUNTU-SAUCE-apparmor-ensure-that-repacedby-s.patch"
SRC_URI += "file://1613-Revert-UBUNTU-SAUCE-apparmor-Fix-update-replacedby-a.patch"
SRC_URI += "file://1614-Revert-UBUNTU-SAUCE-apparmor-Fix-convert-replacedby-.patch"
SRC_URI += "file://1615-Revert-UBUNTU-SAUCE-apparmor-Fix-add-required-lockin.patch"
SRC_URI += "file://1616-Revert-UBUNTU-SAUCE-apparmor-Fix-deadlock-in-aa_put_.patch"
SRC_URI += "file://1617-Revert-UBUNTU-SAUCE-apparmor-Fix-label_vec_merge-ins.patch"
SRC_URI += "file://1618-Revert-UBUNTU-SAUCE-apparmor-Fix-ensure-new-labels-r.patch"
SRC_URI += "file://1619-Revert-UBUNTU-SAUCE-apparmor-Fix-refcount-leak-in-aa.patch"
SRC_URI += "file://1620-Revert-UBUNTU-SAUCE-apparmor-Fix-refcount-race-betwe.patch"
SRC_URI += "file://1621-Revert-UBUNTU-SAUCE-apparmor-Fix-label-merge-handlin.patch"
SRC_URI += "file://1622-Revert-UBUNTU-SAUCE-apparmor-add-underscores-to-indi.patch"
SRC_URI += "file://1623-Revert-UBUNTU-SAUCE-apparmor-debug-POISON-label-and-.patch"
SRC_URI += "file://1624-Revert-UBUNTU-SAUCE-apparmor-Fix-ensure-aa_get_newes.patch"
SRC_URI += "file://1625-Revert-UBUNTU-SAUCE-apparmor-Fix-insert-race-between.patch"
SRC_URI += "file://1626-Revert-UBUNTU-SAUCE-apparmor-rework-retrieval-of-the.patch"
SRC_URI += "file://1627-Revert-UBUNTU-SAUCE-apparmor-Disallow-update-of-cred.patch"
SRC_URI += "file://1628-Revert-UBUNTU-SAUCE-apparmor-Fix-oops-do-to-invalid-.patch"
SRC_URI += "file://1629-Revert-UBUNTU-SAUCE-fix-up-kern_mount-fail-path-shou.patch"
SRC_URI += "file://1630-Revert-UBUNTU-SAUCE-apparmor-fix-sleep-from-invalid-.patch"
SRC_URI += "file://1631-Revert-UBUNTU-SAUCE-no-up-apparmor-fix-for-failed-me.patch"
SRC_URI += "file://1632-Revert-UBUNTU-SAUCE-no-up-apparmor-Fix-incompatible-.patch"
SRC_URI += "file://1633-Revert-UBUNTU-SAUCE-no-up-apparmor-fix-mount-not-han.patch"
SRC_URI += "file://1634-Revert-UBUNTU-SAUCE-no-up-apparmor-fix-mediation-of-.patch"
SRC_URI += "file://1635-Revert-UBUNTU-apparmor-follow-change-to-this_cpu_ptr.patch"
SRC_URI += "file://1636-Revert-UBUNTU-SAUCE-no-up-fix-bad-unix_addr_fs-macro.patch"
SRC_URI += "file://1637-Revert-UBUNTU-SAUCE-Revert-fix-only-allow-a-single-t.patch"
SRC_URI += "file://1638-Revert-UBUNTU-SAUCE-no-up-apparmor-Sync-to-apparmor3.patch"
SRC_URI += "file://1639-Revert-UBUNTU-SAUCE-no-up-apparmor-add-parameter-to-.patch"
SRC_URI += "file://1640-UBUNTU-SAUCE-no-up-apparmor-sync-of-apparmor3.5-beta.patch"
SRC_URI += "file://1641-UBUNTU-SAUCE-add-a-sysctl-to-enable-unprivileged-use.patch"
SRC_URI += "file://1642-UBUNTU-SAUCE-noup-cxl-Allow-initialization-on-timeba.patch"
SRC_URI += "file://1643-EDAC-sb_edac-Fix-computation-of-channel-address.patch"
SRC_URI += "file://1644-drivers-perf-kill-armpmu_register.patch"
SRC_URI += "file://1645-arm-perf-Convert-event-enums-to-defines.patch"
SRC_URI += "file://1646-arm-perf-Add-event-descriptions.patch"
SRC_URI += "file://1647-arm64-perf-Convert-event-enums-to-defines.patch"
SRC_URI += "file://1648-arm64-perf-Add-event-descriptions.patch"
SRC_URI += "file://1649-ARM-perf-add-format-entry-to-describe-event-config-m.patch"
SRC_URI += "file://1650-arm64-perf-add-format-entry-to-describe-event-config.patch"
SRC_URI += "file://1651-arm64-perf-Rename-Cortex-A57-events.patch"
SRC_URI += "file://1652-arm64-perf-Add-Cavium-ThunderX-PMU-support.patch"
SRC_URI += "file://1653-arm64-perf-Enable-PMCR-long-cycle-counter-bit.patch"
SRC_URI += "file://1654-arm64-perf-Extend-event-mask-for-ARMv8.1.patch"
SRC_URI += "file://1655-arm64-dts-Add-Cavium-ThunderX-specific-PMU.patch"
SRC_URI += "file://1656-arcmsr-fixed-getting-wrong-configuration-data.patch"
SRC_URI += "file://1657-arcmsr-fixes-not-release-allocated-resource.patch"
SRC_URI += "file://1658-arcmsr-make-code-more-readable.patch"
SRC_URI += "file://1659-arcmsr-adds-code-to-support-new-Areca-adapter-ARC120.patch"
SRC_URI += "file://1660-arcmsr-changes-driver-version-number.patch"
SRC_URI += "file://1661-arcmsr-more-readability-improvements.patch"
SRC_URI += "file://1662-arcmsr-Split-dma-resource-allocation-to-a-new-functi.patch"
SRC_URI += "file://1663-arcmsr-change-driver-version-to-v1.30.00.22-20151126.patch"
SRC_URI += "file://1664-UBUNTU-SAUCE-no-up-arm64-gicv3-its-Increase-FORCE_MA.patch"
SRC_URI += "file://1665-Revert-hrtimer-Add-support-for-CLOCK_MONOTONIC_RAW.patch"
SRC_URI += "file://1666-Revert-hrtimer-Catch-illegal-clockids.patch"
SRC_URI += "file://1667-Revert-KVM-arm-arm64-timer-Switch-to-CLOCK_MONOTONIC.patch"
SRC_URI += "file://1668-UBUNTU-SAUCE-noup-cgroup-namespaces-add-a-nsroot-mou.patch"
SRC_URI += "file://1669-UBUNTU-SAUCE-noup-fuse-do-not-use-iocb-after-it-may-.patch"
SRC_URI += "file://1670-UBUNTU-SAUCE-noup-fuse-Add-reference-counting-for-fu.patch"
SRC_URI += "file://1671-UBUNTU-SAUCE-apparmor-Allow-ns_root-processes-to-ope.patch"
SRC_URI += "file://1672-UBUNTU-SAUCE-apparmor-Consult-sysctl-when-reading-pr.patch"
SRC_URI += "file://1673-UBUNTU-SAUCE-noup-Input-synaptics-handle-spurious-re.patch"
SRC_URI += "file://1674-Thermal-Ignore-invalid-trip-points.patch"
SRC_URI += "file://1675-mfd-intel-lpss-Pass-I2C-configuration-via-properties.patch"
SRC_URI += "file://1676-perf-x86-Move-perf_event.c-.-x86-events-core.c.patch"
SRC_URI += "file://1677-perf-x86-Move-perf_event_amd.c-.-x86-events-amd-core.patch"
SRC_URI += "file://1678-perf-x86-Move-perf_event_amd_ibs.c-.-x86-events-amd-.patch"
SRC_URI += "file://1679-perf-x86-Move-perf_event_amd_iommu.-ch-.-x86-events-.patch"
SRC_URI += "file://1680-perf-x86-Move-perf_event_amd_uncore.c-.-x86-events-a.patch"
SRC_URI += "file://1681-perf-x86-Move-perf_event_intel_bts.c-.-x86-events-in.patch"
SRC_URI += "file://1682-perf-x86-Move-perf_event_intel.c-.-x86-events-intel-.patch"
SRC_URI += "file://1683-perf-x86-Move-perf_event_intel_cqm.c-.-x86-events-in.patch"
SRC_URI += "file://1684-perf-x86-Move-perf_event_intel_cstate.c-.-x86-events.patch"
SRC_URI += "file://1685-perf-x86-Move-perf_event_intel_ds.c-.-x86-events-int.patch"
SRC_URI += "file://1686-perf-x86-Move-perf_event_intel_lbr.c-.-x86-events-in.patch"
SRC_URI += "file://1687-perf-x86-Move-perf_event_intel_pt.-ch-.-x86-events-i.patch"
SRC_URI += "file://1688-perf-x86-Move-perf_event_intel_rapl.c-.-x86-events-i.patch"
SRC_URI += "file://1689-perf-x86-Move-perf_event_intel_uncore.-ch-.-x86-even.patch"
SRC_URI += "file://1690-perf-x86-Move-perf_event_intel_uncore_nhmex.c-x86-ev.patch"
SRC_URI += "file://1691-perf-x86-Move-perf_event_intel_uncore_snb.c-x86-even.patch"
SRC_URI += "file://1692-perf-x86-Move-perf_event_intel_uncore_snbep.c-x86-ev.patch"
SRC_URI += "file://1693-perf-x86-Move-perf_event_knc.c-.-x86-events-intel-kn.patch"
SRC_URI += "file://1694-perf-x86-Move-perf_event_p4.c-.-x86-events-intel-p4..patch"
SRC_URI += "file://1695-perf-x86-Move-perf_event_p6.c-.-x86-events-intel-p6..patch"
SRC_URI += "file://1696-perf-x86-Move-perf_event_msr.c-.-x86-events-msr.c.patch"
SRC_URI += "file://1697-perf-x86-Move-perf_event.h-to-its-new-home.patch"
SRC_URI += "file://1698-perf-x86-intel-Use-PAGE_SIZE-for-PEBS-buffer-size-on.patch"
SRC_URI += "file://1699-clk-xgene-Add-SoC-and-PMD-PLL-clocks-with-v2-hardwar.patch"
SRC_URI += "file://1700-time-Verify-time-values-in-adjtimex-ADJ_SETOFFSET-to.patch"
SRC_URI += "file://1701-timekeeping-Provide-internal-function-__ktime_get_re.patch"
SRC_URI += "file://1702-timekeeping-Cap-adjustments-so-they-don-t-exceed-the.patch"
SRC_URI += "file://1703-clocksource-Make-clocksource-validation-work-for-all.patch"
SRC_URI += "file://1704-time-Add-cycles-to-nanoseconds-translation.patch"
SRC_URI += "file://1705-time-Add-timekeeping-snapshot-code-capturing-system-.patch"
SRC_URI += "file://1706-time-Remove-duplicated-code-in-ktime_get_raw_and_rea.patch"
SRC_URI += "file://1707-time-Add-driver-cross-timestamp-interface-for-higher.patch"
SRC_URI += "file://1708-time-Add-history-to-cross-timestamp-interface-suppor.patch"
SRC_URI += "file://1709-time-timekeeping-Work-around-false-positive-GCC-warn.patch"
SRC_URI += "file://1710-x86-tsc-Always-Running-Timer-ART-correlated-clocksou.patch"
SRC_URI += "file://1711-ptp-Add-PTP_SYS_OFFSET_PRECISE-for-driver-crosstimes.patch"
SRC_URI += "file://1712-e1000e-Adds-hardware-supported-cross-timestamp-on-e1.patch"
SRC_URI += "file://1713-net-add-netif_is_team_master-helper.patch"
SRC_URI += "file://1714-net-add-netif_is_team_port-helper.patch"
SRC_URI += "file://1715-net-add-netif_is_lag_master-helper.patch"
SRC_URI += "file://1716-net-add-netif_is_lag_port-helper.patch"
SRC_URI += "file://1717-ethtool-correctly-ensure-GS-CHANNELS-doesn-t-conflic.patch"
SRC_URI += "file://1718-fm10k-don-t-reinitialize-RSS-flow-table-when-RXFH-co.patch"
SRC_URI += "file://1719-net-add-tc-offload-feature-flag.patch"
SRC_URI += "file://1720-net-tc-helper-functions-to-query-action-types.patch"
SRC_URI += "file://1721-sctp-Rename-NETIF_F_SCTP_CSUM-to-NETIF_F_SCTP_CRC.patch"
SRC_URI += "file://1722-net-rework-ndo-tc-op-to-consume-additional-qdisc-han.patch"
SRC_URI += "file://1723-net-rework-setup_tc-ndo-op-to-consume-general-tc-ope.patch"
SRC_URI += "file://1724-net-sched-add-cls_u32-offload-hooks-for-netdevs.patch"
SRC_URI += "file://1725-net-ixgbe-add-support-for-tc_u32-offload.patch"
SRC_URI += "file://1726-net-ixgbe-abort-with-cls-u32-divisor-groups-greater-.patch"
SRC_URI += "file://1727-intel_idle-prevent-SKL-H-boot-failure-when-C8-C9-C10.patch"
SRC_URI += "file://1728-drivers-hv-Move-VMBus-hypercall-codes-into-Hyper-V-U.patch"
SRC_URI += "file://1729-PM-runtime-Add-new-helper-for-conditional-usage-coun.patch"
SRC_URI += "file://1730-drm-core-Add-drm_for_each_encoder_mask-v2.patch"
SRC_URI += "file://1731-drm-atomic-helper-Implement-subsystem-level-suspend-.patch"
SRC_URI += "file://1732-printk-set-may_schedule-for-some-of-console_trylock-.patch"
SRC_URI += "file://1733-net-thunderx-Cleanup-PHY-probing-code.patch"
SRC_URI += "file://1734-phy-mdio-octeon-Refactor-into-two-files-modules.patch"
SRC_URI += "file://1735-phy-mdio-thunder-Add-driver-for-Cavium-Thunder-SoC-M.patch"
SRC_URI += "file://1736-phy-mdio-cavium-Add-missing-MODULE_-annotations.patch"
SRC_URI += "file://1737-net-cavium-For-Kconfig-THUNDER_NIC_BGX-select-MDIO_T.patch"
SRC_URI += "file://1738-phy-mdio-thunder-Fix-some-Kconfig-typos.patch"
SRC_URI += "file://1739-UBUNTU-SAUCE-noup-ppc64-boot-Wait-for-boot-cpu-to-sh.patch"
SRC_URI += "file://1740-net-thunderx-Fix-for-multiqset-not-configured-upon-i.patch"
SRC_URI += "file://1741-net-thunderx-Fix-for-HW-TSO-not-enabled-for-secondar.patch"
SRC_URI += "file://1742-net-thunderx-Fix-receive-packet-stats.patch"
SRC_URI += "file://1743-net-thunderx-Set-recevie-buffer-page-usage-count-in-.patch"
SRC_URI += "file://1744-net-thunderx-Adjust-nicvf-structure-to-reduce-cache-.patch"
SRC_URI += "file://1745-i2c-octeon-Cleanup-kerneldoc-comments.patch"
SRC_URI += "file://1746-i2c-octeon-Cleanup-i2c-octeon-driver.patch"
SRC_URI += "file://1747-i2c-octeon-Cleanup-resource-allocation-code.patch"
SRC_URI += "file://1748-i2c-octeon-Support-I2C_M_RECV_LEN.patch"
SRC_URI += "file://1749-arm64-Honour-PTE_WRITE-in-set_pte_at-for-kernel-mapp.patch"
SRC_URI += "file://1750-arm64-Update-PTE_RDONLY-in-set_pte_at-for-PROT_NONE-.patch"
SRC_URI += "file://1751-UBUNTU-SAUCE-PATCH-v4-irqchip-gicv3-its-numa-Enable-.patch"
SRC_URI += "file://1752-UBUNTU-SAUCE-PATCH-V2-iommu-arm-smmu-v2-Add-support-.patch"
SRC_URI += "file://1753-UBUNTU-SAUCE-PATCH-V4-iommu-arm-smmu-v2-Workaround-f.patch"
SRC_URI += "file://1754-UBUNTU-SAUCE-PATCH-v5-01-14-i2c-octeon-Increase-retr.patch"
SRC_URI += "file://1755-UBUNTU-SAUCE-PATCH-v5-02-14-i2c-octeon-Move-set-cloc.patch"
SRC_URI += "file://1756-UBUNTU-SAUCE-PATCH-v5-03-14-i2c-octeon-Improve-error.patch"
SRC_URI += "file://1757-UBUNTU-SAUCE-PATCH-v5-04-14-i2c-octeon-Enable-High-L.patch"
SRC_URI += "file://1758-UBUNTU-SAUCE-PATCH-v5-05-14-dt-bindings-i2c-Add-Octe.patch"
SRC_URI += "file://1759-UBUNTU-SAUCE-PATCH-v5-06-14-i2c-octeon-Add-support-f.patch"
SRC_URI += "file://1760-UBUNTU-SAUCE-PATCH-v5-07-14-i2c-octeon-Flush-TWSI-wr.patch"
SRC_URI += "file://1761-UBUNTU-SAUCE-PATCH-v5-08-14-i2c-octeon-Faster-operat.patch"
SRC_URI += "file://1762-UBUNTU-SAUCE-PATCH-v5-09-14-i2c-octeon-Add-workaroun.patch"
SRC_URI += "file://1763-UBUNTU-SAUCE-PATCH-v5-10-14-i2c-octeon-Move-read-fun.patch"
SRC_URI += "file://1764-UBUNTU-SAUCE-PATCH-v5-11-14-i2c-octeon-Rename-driver.patch"
SRC_URI += "file://1765-UBUNTU-SAUCE-PATCH-v5-12-14-i2c-octeon-Split-the-dri.patch"
SRC_URI += "file://1766-UBUNTU-SAUCE-PATCH-v5-13-14-i2c-thunderx-Add-i2c-dri.patch"
SRC_URI += "file://1767-UBUNTU-SAUCE-PATCH-v5-14-14-i2c-thunderx-Add-smbus-a.patch"
include 81XX_patches.inc
include ilp32_4_4_patches.inc
S = "${WORKDIR}/git"

do_package_qa() {
	echo "do_package_qa commented hack"
}


addtask deploy after do_install
addtask shared_workdir after do_compile before do_install
FILES_kernel-image += "/boot/Image*"
KERNEL_EXTRA_ARGS += "LOADADDR=${UBOOT_ENTRYPOINT}"
LDFLAGS += "-lssl -lcrypto"
